# Repository isarmg/pcie-switch-2 (continued)

## KiCad design outputs/PCIe_3board_RevK/Main_10E1S/Main_10E1S.kicad_pcb (continued)

Schematic: Connectivity_01.kicad_sch, Main_10E1S / Connectivity 01

Parts:
U1: Broadcom PEX88096 / SS02-0B00-00; Broadcom_PEX88096_BGA1550_37p5x42p5_1mm

Connections:
/CPU_PEX_RX0_N: U1.AF30 (RXN[0])
/CPU_PEX_RX0_P: U1.AF31 (RXP[0])
/CPU_PEX_RX1_N: U1.AG32 (RXN[1])
/CPU_PEX_RX1_P: U1.AG33 (RXP[1])
/CPU_PEX_RX2_N: U1.AH30 (RXN[2])
/CPU_PEX_RX2_P: U1.AH31 (RXP[2])
/CPU_PEX_RX3_N: U1.AJ32 (RXN[3])
/CPU_PEX_RX3_P: U1.AJ33 (RXP[3])
/CPU_PEX_TX0_N: U1.AF35 (TXN[0])
/CPU_PEX_TX0_P: U1.AF36 (TXP[0])
/CPU_PEX_TX1_N: U1.AG36 (TXN[1])
/CPU_PEX_TX1_P: U1.AG37 (TXP[1])
/CPU_PEX_TX2_N: U1.AH35 (TXN[2])
/CPU_PEX_TX2_P: U1.AH36 (TXP[2])
/CPU_PEX_TX3_N: U1.AJ36 (TXN[3])
/CPU_PEX_TX3_P: U1.AJ37 (TXP[3])
/CPU_REFCLK_N: U1.AB6 (S0_PCE_REF_CLK_N)
/CPU_REFCLK_P: U1.AB5 (S0_PCE_REF_CLK_P)
/GND: U1.A2 (VSS), U1.A11 (VSS), U1.A13 (VSS), U1.A15 (VSS), U1.A17 (VSS), U1.A19 (VSS), U1.A21 (VSS), U1.A23 (VSS), U1.A25 (VSS), U1.A35 (VSS), U1.A36 (VSS), U1.AA1 (VSS), U1.AA2 (VSS), U1.AA5 (VSS), U1.AA6 (VSS), U1.AA7 (VSS), U1.AA14 (VSS), U1.AA16 (VSS), U1.AA18 (VSS), U1.AA20 (VSS), U1.AA22 (VSS), U1.AA24 (VSS), U1.AA25 (VSS), U1.AA26 (VSS), U1.AA27 (VSS), U1.AA28 (VSS), U1.AA33 (VSS), U1.AB3 (VSS), U1.AB4 (VSS), U1.AB7 (VSS), U1.AB15 (VSS), U1.AB17 (VSS), U1.AB19 (VSS), U1.AB21 (VSS), U1.AB23 (VSS), U1.AB25 (VSS), U1.AB26 (VSS), U1.AB27 (VSS), U1.AB29 (VSS), U1.AB34 (VSS), U1.AC1 (VSS), U1.AC2 (VSS), U1.AC3 (VSS), U1.AC4 (VSS), U1.AC5 (VSS), U1.AC6 (VSS), U1.AC7 (VSS), U1.AC8 (VSS), U1.AC9 (VSS), U1.AC14 (VSS), U1.AC16 (VSS), U1.AC18 (VSS), U1.AC20 (VSS), U1.AC22 (VSS), U1.AC24 (VSS), U1.AC25 (VSS), U1.AC26 (VSS), U1.AC27 (VSS), U1.AC28 (VSS), U1.AC33 (VSS), U1.AD1 (VSS), U1.AD4 (VSS), U1.AD5 (VSS), U1.AD6 (VSS), U1.AD9 (VSS), U1.AD12 (VSS), U1.AD15 (VSS), U1.AD17 (VSS), U1.AD19 (VSS), U1.AD21 (VSS), U1.AD23 (VSS), U1.AD25 (VSS), U1.AD26 (VSS), U1.AD27 (VSS), U1.AD29 (VSS), U1.AD34 (VSS), U1.AE3 (VSS), U1.AE4 (VSS), U1.AE7 (VSS), U1.AE8 (VSS), U1.AE9 (VSS), U1.AE12 (VSS), U1.AE14 (VSS), U1.AE16 (VSS), U1.AE18 (VSS), U1.AE20 (VSS), U1.AE22 (VSS), U1.AE24 (VSS), U1.AE26 (VSS), U1.AE29 (VSS), U1.AE30 (VSS), U1.AE31 (VSS), U1.AE32 (VSS), U1.AE34 (VSS), U1.AE35 (VSS), U1.AE36 (VSS), U1.AE37 (VSS), U1.AF1 (VSS), U1.AF4 (VSS), U1.AF5 (VSS), U1.AF6 (VSS), U1.AF9 (VSS), U1.AF12 (VSS), U1.AF15 (VSS), U1.AF17 (VSS), U1.AF19 (VSS), U1.AF21 (VSS), U1.AF23 (VSS), U1.AF26 (VSS), U1.AF29 (VSS), U1.AF32 (VSS), U1.AF33 (VSS), U1.AF34 (VSS), U1.AF37 (VSS), U1.AG3 (VSS), U1.AG4 (VSS), U1.AG7 (VSS), U1.AG8 (VSS), U1.AG9 (VSS), U1.AG12 (VSS), U1.AG26 (VSS), U1.AG29 (VSS), U1.AG30 (VSS), U1.AG31 (VSS), U1.AG34 (VSS), U1.AG35 (VSS), U1.AH1 (VSS), U1.AH4 (VSS), U1.AH5 (VSS), U1.AH6 (VSS), U1.AH9 (VSS), U1.AH12 (VSS), U1.AH14 (VSS), U1.AH15 (VSS), U1.AH17 (VSS), U1.AH19 (VSS), U1.AH21 (VSS), U1.AH23 (VSS), U1.AH24 (VSS), U1.AH26 (VSS), U1.AH29 (VSS), U1.AH32 (VSS), U1.AH33 (VSS), U1.AH34 (VSS), U1.AH37 (VSS), U1.AJ3 (VSS), U1.AJ4 (VSS), U1.AJ7 (VSS), U1.AJ8 (VSS), U1.AJ9 (VSS), U1.AJ12 (VSS), U1.AJ26 (VSS), U1.AJ29 (VSS), U1.AJ30 (VSS), U1.AJ31 (VSS), U1.AJ34 (VSS), U1.AJ35 (VSS), U1.AK1 (VSS), U1.AK4 (VSS), U1.AK5 (VSS), U1.AK6 (VSS), U1.AK9 (VSS), U1.AK10 (VSS), U1.AK11 (VSS), U1.AK13 (VSS), U1.AK25 (VSS), U1.AK27 (VSS), U1.AK28 (VSS), U1.AK29 (VSS), U1.AK32 (VSS), U1.AK33 (VSS), U1.AK34 (VSS), U1.AK37 (VSS), U1.AL3 (VSS), U1.AL4 (VSS), U1.AL7 (VSS), U1.AL8 (VSS), U1.AL9 (VSS), U1.AL10 (VSS), U1.AL11 (VSS), U1.AL12 (VSS), U1.AL13 (VSS), U1.AL14 (VSS), U1.AL15 (VSS), U1.AL16 (VSS), U1.AL17 (VSS), U1.AL18 (VSS), U1.AL19 (VSS), U1.AL20 (VSS), U1.AL21 (VSS), U1.AL22 (VSS), U1.AL23 (VSS), U1.AL24 (VSS), U1.AL25 (VSS), U1.AL26 (VSS), U1.AL27 (VSS), U1.AL28 (VSS), U1.AL29 (VSS), U1.AL30 (VSS), U1.AL31 (VSS), U1.AL34 (VSS), U1.AL35 (VSS), U1.AM1 (VSS), U1.AM4 (VSS), U1.AM5 (VSS), U1.AM6 (VSS), U1.AM9 (VSS), U1.AM10 (VSS), U1.AM11 (VSS), U1.AM12 (VSS), U1.AM13 (VSS), U1.AM14 (VSS), U1.AM15 (VSS), U1.AM16 (VSS), U1.AM17 (VSS), U1.AM18 (VSS), U1.AM19 (VSS), U1.AM20 (VSS), U1.AM21 (VSS), U1.AM22 (VSS), U1.AM23 (VSS), U1.AM24 (VSS), U1.AM25 (VSS), U1.AM26 (VSS), U1.AM27 (VSS), U1.AM28 (VSS), U1.AM29 (VSS), U1.AM32 (VSS), U1.AM33 (VSS), U1.AM34 (VSS), U1.AM37 (VSS), U1.AN3 (VSS), U1.AN4 (VSS), U1.AN7 (VSS), U1.AN8 (VSS), U1.AN9 (VSS), U1.AN10 (VSS), U1.AN11 (VSS), U1.AN12 (VSS), U1.AN13 (VSS), U1.AN14 (VSS), U1.AN15 (VSS), U1.AN16 (VSS), U1.AN17 (VSS), U1.AN18 (VSS), U1.AN19 (VSS), U1.AN20 (VSS), U1.AN21 (VSS), U1.AN22 (VSS), U1.AN23 (VSS), U1.AN24 (VSS), U1.AN25 (VSS), U1.AN26 (VSS), U1.AN27 (VSS), U1.AN28 (VSS), U1.AN29 (VSS), U1.AN30 (VSS), U1.AN31 (VSS), U1.AN34 (VSS), U1.AN35 (VSS), U1.AP1 (VSS), U1.AP2 (VSS), U1.AP3 (VSS), U1.AP4 (VSS), U1.AP5 (VSS), U1.AP6 (VSS), U1.AP7 (VSS), U1.AP8 (VSS), U1.AP9 (VSS), U1.AP10 (VSS), U1.AP11 (VSS), U1.AP12 (VSS), U1.AP13 (VSS), U1.AP14 (VSS), U1.AP15 (VSS), U1.AP16 (VSS), U1.AP17 (VSS), U1.AP18 (VSS), U1.AP19 (VSS), U1.AP20 (VSS), U1.AP21 (VSS), U1.AP22 (VSS), U1.AP23 (VSS), U1.AP24 (VSS), U1.AP25 (VSS), U1.AP26 (VSS), U1.AP27 (VSS), U1.AP28 (VSS), U1.AP29 (VSS), U1.AP30 (VSS), U1.AP31 (VSS), U1.AP32 (VSS), U1.AP33 (VSS), U1.AP34 (VSS), U1.AP35 (VSS), U1.AP36 (VSS), U1.AP37 (VSS), U1.AR1 (VSS), U1.AR2 (VSS), U1.AR3 (VSS), U1.AR5 (VSS), U1.AR7 (VSS), U1.AR9 (VSS), U1.AR11 (VSS), U1.AR13 (VSS), U1.AR15 (VSS), U1.AR17 (VSS), U1.AR19 (VSS), U1.AR21 (VSS), U1.AR23 (VSS), U1.AR25 (VSS), U1.AR27 (VSS), U1.AR29 (VSS), U1.AR31 (VSS), U1.AR33 (VSS), U1.AR35 (VSS), U1.AT1 (VSS), U1.AT2 (VSS), U1.AT3 (VSS), U1.AT5 (VSS), U1.AT7 (VSS), U1.AT9 (VSS), U1.AT11 (VSS), U1.AT13 (VSS), U1.AT15 (VSS), U1.AT17 (VSS), U1.AT19 (VSS), U1.AT21 (VSS), U1.AT23 (VSS), U1.AT25 (VSS), U1.AT27 (VSS), U1.AT29 (VSS), U1.AT31 (VSS), U1.AT33 (VSS), U1.AT35 (VSS), U1.AU1 (VSS), U1.AU2 (VSS), U1.AU4 (VSS), U1.AU6 (VSS), U1.AU8 (VSS), U1.AU10 (VSS), U1.AU12 (VSS), U1.AU14 (VSS), U1.AU16 (VSS), U1.AU18 (VSS), U1.AU20 (VSS), U1.AU22 (VSS), U1.AU24 (VSS), U1.AU26 (VSS), U1.AU28 (VSS), U1.AU30 (VSS), U1.AU32 (VSS), U1.AU34 (VSS), U1.AU35 (VSS), U1.AV1 (VSS), U1.AV2 (VSS), U1.AV4 (VSS), U1.AV6 (VSS), U1.AV8 (VSS), U1.AV10 (VSS), U1.AV12 (VSS), U1.AV14 (VSS), U1.AV16 (VSS), U1.AV18 (VSS), U1.AV20 (VSS), U1.AV22 (VSS), U1.AV24 (VSS), U1.AV26 (VSS), U1.AV28 (VSS), U1.AV30 (VSS), U1.AV32 (VSS), U1.AV34 (VSS), U1.AV35 (VSS), U1.AW1 (VSS), U1.AW2 (VSS), U1.AW3 (VSS), U1.AW4 (VSS), U1.AW5 (VSS), U1.AW6 (VSS), U1.AW7 (VSS), U1.AW8 (VSS), U1.AW9 (VSS), U1.AW10 (VSS), U1.AW11 (VSS), U1.AW12 (VSS), U1.AW13 (VSS), U1.AW14 (VSS), U1.AW15 (VSS), U1.AW16 (VSS), U1.AW17 (VSS), U1.AW18 (VSS), U1.AW19 (VSS); also elsewhere on the board
/M1_RX0_N: U1.AJ6 (RXN[44]); also elsewhere on the board
/M1_RX0_P: U1.AJ5 (RXP[44]); also elsewhere on the board
/M1_RX1_N: U1.AH8 (RXN[45]); also elsewhere on the board
/M1_RX1_P: U1.AH7 (RXP[45]); also elsewhere on the board
/M1_RX2_N: U1.AG6 (RXN[46]); also elsewhere on the board
/M1_RX2_P: U1.AG5 (RXP[46]); also elsewhere on the board
/M1_RX3_N: U1.AF8 (RXN[47]); also elsewhere on the board
/M1_RX3_P: U1.AF7 (RXP[47]); also elsewhere on the board
/M1_TX0_N: U1.AJ2 (TXN[44]); also elsewhere on the board
/M1_TX0_P: U1.AJ1 (TXP[44]); also elsewhere on the board
/M1_TX1_N: U1.AH3 (TXN[45]); also elsewhere on the board
/M1_TX1_P: U1.AH2 (TXP[45]); also elsewhere on the board
/M1_TX2_N: U1.AG2 (TXN[46]); also elsewhere on the board
/M1_TX2_P: U1.AG1 (TXP[46]); also elsewhere on the board
/M1_TX3_N: U1.AF3 (TXN[47]); also elsewhere on the board
/M1_TX3_P: U1.AF2 (TXP[47]); also elsewhere on the board
/M3_TX0_P: U1.A34 (TXP[56]); also elsewhere on the board
/M3_TX1_P: U1.A33 (TXP[57]); also elsewhere on the board
/M3_TX2_P: U1.A32 (TXP[58]); also elsewhere on the board
/M3_TX3_P: U1.A31 (TXP[59]); also elsewhere on the board
/M5_TX0_P: U1.A30 (TXP[60]); also elsewhere on the board
/M5_TX1_P: U1.A29 (TXP[61]); also elsewhere on the board
/M5_TX2_P: U1.A28 (TXP[62]); also elsewhere on the board
/M5_TX3_P: U1.A27 (TXP[63]); also elsewhere on the board
/PEX_0V9: U1.AA15 (VDD), U1.AA17 (VDD), U1.AA19 (VDD), U1.AA21 (VDD), U1.AA23 (VDD), U1.AB14 (VDD), U1.AB16 (VDD), U1.AB18 (VDD), U1.AB20 (VDD), U1.AB22 (VDD), U1.AB24 (VDD), U1.AC15 (VDD), U1.AC17 (VDD), U1.AC19 (VDD), U1.AC21 (VDD), U1.AC23 (VDD), U1.AD14 (VDD), U1.AD16 (VDD), U1.AD18 (VDD), U1.AD20 (VDD), U1.AD22 (VDD), U1.AD24 (VDD), U1.AE15 (VDD), U1.AE17 (VDD), U1.AE19 (VDD), U1.AE21 (VDD), U1.AE23 (VDD), U1.AF14 (VDD), U1.AF16 (VDD), U1.AF18 (VDD), U1.AF20 (VDD), U1.AF22 (VDD), U1.AF24 (VDD); also elsewhere on the board
/PEX_0V9A: U1.AD13 (VDDA), U1.AE13 (VDDA), U1.AE25 (VDDA), U1.AF13 (VDDA), U1.AF25 (VDDA), U1.AG13 (VDDA), U1.AG15 (VDDA), U1.AG17 (VDDA), U1.AG19 (VDDA), U1.AG21 (VDDA), U1.AG23 (VDDA), U1.AG25 (VDDA), U1.AH13 (VDDA), U1.AH16 (VDDA), U1.AH18 (VDDA), U1.AH20 (VDDA), U1.AH22 (VDDA), U1.AH25 (VDDA), U1.AJ13 (VDDA), U1.AJ15 (VDDA), U1.AJ17 (VDDA), U1.AJ19 (VDDA), U1.AJ21 (VDDA), U1.AJ23 (VDDA), U1.AJ25 (VDDA), U1.AK14 (VDDA), U1.AK16 (VDDA), U1.AK18 (VDDA), U1.AK20 (VDDA), U1.AK22 (VDDA), U1.AK24 (VDDA); also elsewhere on the board
/PEX_1V8: U1.AA29 (VDD18), U1.AA34 (VDD18), U1.AB28 (VDD18), U1.AB33 (VDD18), U1.AC10 (VDD18), U1.AC11 (VDD18), U1.AC29 (VDD18), U1.AC34 (VDD18), U1.AD11 (VDD1x), U1.AD28 (VDD18), U1.AD33 (VDD18), U1.AE11 (VDD1x), U1.AE27 (VDD1x), U1.AF11 (VDD1x), U1.AF27 (VDD1x), U1.AG11 (VDD1x), U1.AG14 (VDD1x), U1.AG16 (VDD1x), U1.AG18 (VDD1x), U1.AG20 (VDD1x), U1.AG22 (VDD1x), U1.AG24 (VDD1x), U1.AG27 (VDD1x), U1.AH11 (VDD1x), U1.AH27 (VDD1x), U1.AJ11 (VDD1x), U1.AJ14 (VDD1x), U1.AJ16 (VDD1x), U1.AJ18 (VDD1x), U1.AJ20 (VDD1x), U1.AJ22 (VDD1x), U1.AJ24 (VDD1x), U1.AJ27 (VDD1x); also elsewhere on the board
/PEX_1V8A: U1.AA12 (VDD18A), U1.AA13 (VDD18A), U1.AB12 (VDD18A), U1.AB13 (VDD18A), U1.AC12 (VDD18A), U1.AC13 (VDD18A), U1.AD10 (VDD1xA), U1.AE10 (VDD1xA), U1.AE28 (VDD1xA), U1.AF10 (VDD1xA), U1.AF28 (VDD1xA), U1.AG10 (VDD1xA), U1.AG28 (VDD1xA), U1.AH10 (VDD1xA), U1.AH28 (VDD1xA), U1.AJ10 (VDD1xA), U1.AJ28 (VDD1xA), U1.AK12 (VDD18A), U1.AK15 (VDD1xA), U1.AK17 (VDD1xA), U1.AK19 (VDD1xA), U1.AK21 (VDD1xA), U1.AK23 (VDD1xA), U1.AK26 (VDD18A); also elsewhere on the board
/PEX_SPI_CLK: U1.AA32 (SPI_CLK); also elsewhere on the board
/PEX_SPI_CS_N: U1.AA35 (SPI_FLASH_CS_N); also elsewhere on the board
/PEX_SPI_RESET_N: U1.AA31 (SPI_RST_N)
/PEX_STRAP_DBG_MODE0: U1.AB30 (DBG_MODE[0])
/PEX_STRAP_DBG_MODE1: U1.AA36 (DBG_MODE[1])
/PEX_STRAP_DBG_MODE2: U1.AA37 (DBG_MODE[2])
/PEX_STRAP_MODE_SEL0: U1.AB36 (MODE_SEL[0])
/PEX_STRAP_MODE_SEL1: U1.AC31 (MODE_SEL[1])
/PEX_STRAP_MODE_SEL2: U1.AR37 (MODE_SEL[2])
/PEX_STRAP_MODE_SEL3: U1.AC30 (MODE_SEL[3])
/PEX_STRAP_MODE_SEL4: U1.AB37 (MODE_SEL[4])
/PEX_STRAP_MODE_SEL6: U1.AB32 (MODE_SEL[6])
/PEX_STRAP_MODE_SEL7: U1.AB35 (MODE_SEL[7])
/PEX_SYS_REFCLK_N: U1.AB2 (SYS_REF_CLK_N)
/PEX_SYS_REFCLK_P: U1.AB1 (SYS_REF_CLK_P)
/S01_SW_RX0_N: U1.AK30 (RXN[4]); also elsewhere on the board
/S01_SW_RX0_P: U1.AK31 (RXP[4]); also elsewhere on the board
/S01_SW_RX1_N: U1.AL32 (RXN[5]); also elsewhere on the board
/S01_SW_RX1_P: U1.AL33 (RXP[5]); also elsewhere on the board
/S01_SW_RX2_N: U1.AM30 (RXN[6]); also elsewhere on the board
/S01_SW_RX2_P: U1.AM31 (RXP[6]); also elsewhere on the board
/S01_SW_RX3_N: U1.AN32 (RXN[7]); also elsewhere on the board
/S01_SW_RX3_P: U1.AN33 (RXP[7]); also elsewhere on the board
/S01_SW_TX0_N: U1.AK35 (TXN[4]); also elsewhere on the board
/S01_SW_TX0_P: U1.AK36 (TXP[4]); also elsewhere on the board
/S01_SW_TX1_N: U1.AL36 (TXN[5]); also elsewhere on the board
/S01_SW_TX1_P: U1.AL37 (TXP[5]); also elsewhere on the board
/S01_SW_TX2_N: U1.AM35 (TXN[6]); also elsewhere on the board
/S01_SW_TX2_P: U1.AM36 (TXP[6]); also elsewhere on the board
/S01_SW_TX3_N: U1.AN36 (TXN[7]); also elsewhere on the board
/S01_SW_TX3_P: U1.AN37 (TXP[7]); also elsewhere on the board
/S02_SW_RX0_N: U1.AR34 (RXN[8]); also elsewhere on the board
/S02_SW_RX0_P: U1.AT34 (RXP[8]); also elsewhere on the board
/S02_SW_RX1_N: U1.AU33 (RXN[9]); also elsewhere on the board
/S02_SW_RX1_P: U1.AV33 (RXP[9]); also elsewhere on the board
/S02_SW_RX2_N: U1.AR32 (RXN[10]); also elsewhere on the board
/S02_SW_RX2_P: U1.AT32 (RXP[10]); also elsewhere on the board
/S02_SW_RX3_N: U1.AU31 (RXN[11]); also elsewhere on the board
/S02_SW_RX3_P: U1.AV31 (RXP[11]); also elsewhere on the board
/S03_SW_RX0_N: U1.AR30 (RXN[12]); also elsewhere on the board
/S03_SW_RX0_P: U1.AT30 (RXP[12]); also elsewhere on the board
/S03_SW_RX1_N: U1.AU29 (RXN[13]); also elsewhere on the board
/S03_SW_RX1_P: U1.AV29 (RXP[13]); also elsewhere on the board
/S03_SW_RX2_N: U1.AR28 (RXN[14]); also elsewhere on the board
/S03_SW_RX2_P: U1.AT28 (RXP[14]); also elsewhere on the board
/S03_SW_RX3_N: U1.AU27 (RXN[15]); also elsewhere on the board
/S03_SW_RX3_P: U1.AV27 (RXP[15]); also elsewhere on the board
/S04_SW_RX0_N: U1.AR26 (RXN[16]); also elsewhere on the board
/S04_SW_RX0_P: U1.AT26 (RXP[16]); also elsewhere on the board
/S04_SW_RX1_N: U1.AU25 (RXN[17]); also elsewhere on the board
/S04_SW_RX1_P: U1.AV25 (RXP[17]); also elsewhere on the board
/S04_SW_RX2_N: U1.AR24 (RXN[18]); also elsewhere on the board
/S04_SW_RX2_P: U1.AT24 (RXP[18]); also elsewhere on the board
/S04_SW_RX3_N: U1.AU23 (RXN[19]); also elsewhere on the board
/S04_SW_RX3_P: U1.AV23 (RXP[19]); also elsewhere on the board
/S05_SW_RX0_N: U1.AR22 (RXN[20]); also elsewhere on the board
/S05_SW_RX0_P: U1.AT22 (RXP[20]); also elsewhere on the board
/S05_SW_RX1_N: U1.AU21 (RXN[21]); also elsewhere on the board
/S05_SW_RX1_P: U1.AV21 (RXP[21]); also elsewhere on the board
/S05_SW_RX2_N: U1.AR20 (RXN[22]); also elsewhere on the board
/S05_SW_RX2_P: U1.AT20 (RXP[22]); also elsewhere on the board
/S05_SW_RX3_N: U1.AU19 (RXN[23]); also elsewhere on the board
/S05_SW_RX3_P: U1.AV19 (RXP[23]); also elsewhere on the board
/S06_SW_RX0_N: U1.AR18 (RXN[24]); also elsewhere on the board
/S06_SW_RX0_P: U1.AT18 (RXP[24]); also elsewhere on the board
/S06_SW_RX1_N: U1.AU17 (RXN[25]); also elsewhere on the board
/S06_SW_RX1_P: U1.AV17 (RXP[25]); also elsewhere on the board
/S06_SW_RX2_N: U1.AR16 (RXN[26]); also elsewhere on the board
/S06_SW_RX2_P: U1.AT16 (RXP[26]); also elsewhere on the board
/S06_SW_RX3_N: U1.AU15 (RXN[27]); also elsewhere on the board
/S06_SW_RX3_P: U1.AV15 (RXP[27]); also elsewhere on the board
/S07_SW_RX0_N: U1.AR14 (RXN[28]); also elsewhere on the board
/S07_SW_RX0_P: U1.AT14 (RXP[28]); also elsewhere on the board
/S07_SW_RX1_N: U1.AU13 (RXN[29]); also elsewhere on the board
/S07_SW_RX1_P: U1.AV13 (RXP[29]); also elsewhere on the board
/S07_SW_RX2_N: U1.AR12 (RXN[30]); also elsewhere on the board
/S07_SW_RX2_P: U1.AT12 (RXP[30]); also elsewhere on the board
/S07_SW_RX3_N: U1.AU11 (RXN[31]); also elsewhere on the board
/S07_SW_RX3_P: U1.AV11 (RXP[31]); also elsewhere on the board
/S08_SW_RX0_N: U1.AR10 (RXN[32]); also elsewhere on the board
/S08_SW_RX0_P: U1.AT10 (RXP[32]); also elsewhere on the board
/S08_SW_RX1_N: U1.AU9 (RXN[33]); also elsewhere on the board
/S08_SW_RX1_P: U1.AV9 (RXP[33]); also elsewhere on the board
/S08_SW_RX2_N: U1.AR8 (RXN[34]); also elsewhere on the board
/S08_SW_RX2_P: U1.AT8 (RXP[34]); also elsewhere on the board
/S08_SW_RX3_N: U1.AU7 (RXN[35]); also elsewhere on the board
/S08_SW_RX3_P: U1.AV7 (RXP[35]); also elsewhere on the board
/S09_SW_RX0_N: U1.AR6 (RXN[36]); also elsewhere on the board
/S09_SW_RX0_P: U1.AT6 (RXP[36]); also elsewhere on the board
/S09_SW_RX1_N: U1.AU5 (RXN[37]); also elsewhere on the board
/S09_SW_RX1_P: U1.AV5 (RXP[37]); also elsewhere on the board
/S09_SW_RX2_N: U1.AR4 (RXN[38]); also elsewhere on the board
/S09_SW_RX2_P: U1.AT4 (RXP[38]); also elsewhere on the board
/S09_SW_RX3_N: U1.AU3 (RXN[39]); also elsewhere on the board
/S09_SW_RX3_P: U1.AV3 (RXP[39]); also elsewhere on the board
/S10_SW_RX0_N: U1.AN6 (RXN[40]); also elsewhere on the board
/S10_SW_RX0_P: U1.AN5 (RXP[40]); also elsewhere on the board
/S10_SW_RX1_N: U1.AM8 (RXN[41]); also elsewhere on the board
/S10_SW_RX1_P: U1.AM7 (RXP[41]); also elsewhere on the board
/S10_SW_RX2_N: U1.AL6 (RXN[42]); also elsewhere on the board
/S10_SW_RX2_P: U1.AL5 (RXP[42]); also elsewhere on the board
/S10_SW_RX3_N: U1.AK8 (RXN[43]); also elsewhere on the board
/S10_SW_RX3_P: U1.AK7 (RXP[43]); also elsewhere on the board
/S10_SW_TX0_N: U1.AN2 (TXN[40]); also elsewhere on the board
/S10_SW_TX0_P: U1.AN1 (TXP[40]); also elsewhere on the board
/S10_SW_TX1_N: U1.AM3 (TXN[41]); also elsewhere on the board
/S10_SW_TX1_P: U1.AM2 (TXP[41]); also elsewhere on the board
/S10_SW_TX2_N: U1.AL2 (TXN[42]); also elsewhere on the board
/S10_SW_TX2_P: U1.AL1 (TXP[42]); also elsewhere on the board
/S10_SW_TX3_N: U1.AK3 (TXN[43]); also elsewhere on the board
/S10_SW_TX3_P: U1.AK2 (TXP[43]); also elsewhere on the board
/UP_TX0_P: U1.A26 (TXP[64]); also elsewhere on the board
/UP_TX2_P: U1.A24 (TXP[66]); also elsewhere on the board

Schematic: Connectivity_02.kicad_sch, Main_10E1S / Connectivity 02

Parts:
U1: Broadcom PEX88096 / SS02-0B00-00; Broadcom_PEX88096_BGA1550_37p5x42p5_1mm

Connections:
/CPU_PERST_1V8_N: U1.E36 (S0_PCE_PERST_N)
/GND: U1.AW20 (VSS), U1.AW21 (VSS), U1.AW22 (VSS), U1.AW23 (VSS), U1.AW24 (VSS), U1.AW25 (VSS), U1.AW26 (VSS), U1.AW27 (VSS), U1.AW28 (VSS), U1.AW29 (VSS), U1.AW30 (VSS), U1.AW31 (VSS), U1.AW32 (VSS), U1.AW33 (VSS), U1.AW34 (VSS), U1.AW35 (VSS), U1.AY1 (VSS), U1.AY2 (VSS), U1.AY3 (VSS), U1.AY5 (VSS), U1.AY7 (VSS), U1.AY9 (VSS), U1.AY11 (VSS), U1.AY13 (VSS), U1.AY15 (VSS), U1.AY17 (VSS), U1.AY19 (VSS), U1.AY21 (VSS), U1.AY23 (VSS), U1.AY25 (VSS), U1.AY27 (VSS), U1.AY29 (VSS), U1.AY31 (VSS), U1.AY33 (VSS), U1.AY35 (VSS), U1.B1 (VSS), U1.B2 (VSS), U1.B35 (VSS), U1.B36 (VSS), U1.B37 (VSS), U1.BA1 (VSS), U1.BA2 (VSS), U1.BA35 (VSS), U1.BA36 (VSS), U1.BA37 (VSS), U1.BB2 (VSS), U1.BB4 (VSS), U1.BB6 (VSS), U1.BB8 (VSS), U1.BB10 (VSS), U1.BB12 (VSS), U1.BB14 (VSS), U1.BB16 (VSS), U1.BB18 (VSS), U1.BB20 (VSS), U1.BB22 (VSS), U1.BB24 (VSS), U1.BB26 (VSS), U1.BB28 (VSS), U1.BB30 (VSS), U1.BB32 (VSS), U1.BB34 (VSS), U1.BB35 (VSS), U1.BB36 (VSS), U1.C1 (VSS), U1.C2 (VSS), U1.C3 (VSS), U1.C4 (VSS), U1.C5 (VSS), U1.C6 (VSS), U1.C7 (VSS), U1.C8 (VSS), U1.C9 (VSS), U1.C10 (VSS), U1.C12 (VSS), U1.C14 (VSS), U1.C16 (VSS), U1.C18 (VSS), U1.C20 (VSS), U1.C22 (VSS), U1.C24 (VSS), U1.C26 (VSS), U1.C27 (VSS), U1.C28 (VSS), U1.C29 (VSS), U1.C30 (VSS), U1.C31 (VSS), U1.C32 (VSS), U1.C33 (VSS), U1.C34 (VSS), U1.C35 (VSS), U1.D1 (VSS), U1.D2 (VSS), U1.D3 (VSS), U1.D5 (VSS), U1.D7 (VSS), U1.D9 (VSS), U1.D11 (VSS), U1.D12 (VSS), U1.D13 (VSS), U1.D14 (VSS), U1.D15 (VSS), U1.D16 (VSS), U1.D17 (VSS), U1.D18 (VSS), U1.D19 (VSS), U1.D20 (VSS), U1.D21 (VSS), U1.D22 (VSS), U1.D23 (VSS), U1.D24 (VSS), U1.D25 (VSS), U1.D26 (VSS), U1.D27 (VSS), U1.D29 (VSS), U1.D31 (VSS), U1.D33 (VSS), U1.D35 (VSS), U1.E1 (VSS), U1.E2 (VSS), U1.E12 (VSS), U1.E14 (VSS), U1.E16 (VSS), U1.E18 (VSS), U1.E20 (VSS), U1.E22 (VSS), U1.E24 (VSS), U1.E26 (VSS), U1.E35 (VSS), U1.F1 (VSS), U1.F2 (VSS), U1.F4 (VSS), U1.F6 (VSS), U1.F8 (VSS), U1.F10 (VSS), U1.F12 (VSS), U1.F14 (VSS), U1.F16 (VSS), U1.F18 (VSS), U1.F20 (VSS), U1.F22 (VSS), U1.F24 (VSS), U1.F26 (VSS), U1.F28 (VSS), U1.F30 (VSS), U1.F32 (VSS), U1.F34 (VSS), U1.F35 (VSS), U1.G1 (VSS), U1.G2 (VSS), U1.G3 (VSS), U1.G4 (VSS), U1.G5 (VSS), U1.G6 (VSS), U1.G7 (VSS), U1.G8 (VSS), U1.G9 (VSS), U1.G10 (VSS), U1.G11 (VSS), U1.G13 (VSS), U1.G15 (VSS), U1.G17 (VSS), U1.G19 (VSS), U1.G21 (VSS), U1.G23 (VSS), U1.G25 (VSS), U1.G27 (VSS), U1.G28 (VSS), U1.G29 (VSS), U1.G30 (VSS), U1.G31 (VSS), U1.G32 (VSS), U1.G33 (VSS), U1.G34 (VSS), U1.G35 (VSS), U1.G36 (VSS), U1.G37 (VSS), U1.H3 (VSS), U1.H6 (VSS), U1.H7 (VSS), U1.H8 (VSS), U1.H9 (VSS), U1.H10 (VSS), U1.H11 (VSS), U1.H13 (VSS), U1.H15 (VSS), U1.H17 (VSS), U1.H19 (VSS), U1.H21 (VSS), U1.H23 (VSS), U1.H25 (VSS), U1.H27 (VSS), U1.H28 (VSS), U1.H29 (VSS), U1.H30 (VSS), U1.H31 (VSS), U1.H32 (VSS), U1.H35 (VSS), U1.J3 (VSS), U1.J4 (VSS), U1.J7 (VSS), U1.J8 (VSS), U1.J9 (VSS), U1.J10 (VSS), U1.J11 (VSS), U1.J12 (VSS), U1.J13 (VSS), U1.J14 (VSS), U1.J15 (VSS), U1.J16 (VSS), U1.J17 (VSS), U1.J18 (VSS), U1.J19 (VSS), U1.J20 (VSS), U1.J21 (VSS), U1.J22 (VSS), U1.J23 (VSS), U1.J24 (VSS), U1.J25 (VSS), U1.J26 (VSS), U1.J27 (VSS), U1.J28 (VSS), U1.J30 (VSS), U1.J31 (VSS), U1.J34 (VSS), U1.J35 (VSS), U1.K3 (VSS), U1.K6 (VSS), U1.K7 (VSS), U1.K8 (VSS), U1.K9 (VSS), U1.K10 (VSS), U1.K11 (VSS), U1.K12 (VSS), U1.K13 (VSS), U1.K14 (VSS), U1.K15 (VSS), U1.K16 (VSS), U1.K17 (VSS), U1.K18 (VSS), U1.K19 (VSS), U1.K20 (VSS), U1.K21 (VSS), U1.K22 (VSS), U1.K23 (VSS), U1.K24 (VSS), U1.K25 (VSS), U1.K26 (VSS), U1.K27 (VSS), U1.K31 (VSS), U1.K32 (VSS), U1.K35 (VSS), U1.L3 (VSS), U1.L4 (VSS), U1.L7 (VSS), U1.L8 (VSS), U1.L9 (VSS), U1.L10 (VSS), U1.L11 (VSS), U1.L12 (VSS), U1.L13 (VSS), U1.L14 (VSS), U1.L15 (VSS), U1.L16 (VSS), U1.L17 (VSS), U1.L18 (VSS), U1.L19 (VSS), U1.L20 (VSS), U1.L21 (VSS), U1.L22 (VSS), U1.L23 (VSS), U1.L24 (VSS), U1.L25 (VSS), U1.L26 (VSS), U1.L27 (VSS), U1.L31 (VSS), U1.L34 (VSS), U1.L35 (VSS), U1.M3 (VSS), U1.M6 (VSS), U1.M7 (VSS), U1.M11 (VSS), U1.M12 (VSS), U1.M13 (VSS), U1.M14 (VSS), U1.M15 (VSS), U1.M16 (VSS), U1.M17 (VSS), U1.M18 (VSS), U1.M19 (VSS), U1.M20 (VSS), U1.M21 (VSS), U1.M22 (VSS), U1.M23 (VSS), U1.M24 (VSS), U1.M25 (VSS), U1.M26 (VSS), U1.M27 (VSS), U1.M31 (VSS), U1.M32 (VSS), U1.M35 (VSS), U1.N3 (VSS), U1.N4 (VSS), U1.N7 (VSS), U1.N11 (VSS), U1.N13 (VSS), U1.N25 (VSS), U1.N27 (VSS), U1.N31 (VSS), U1.N34 (VSS), U1.N35 (VSS), U1.P3 (VSS), U1.P6 (VSS), U1.P7 (VSS), U1.P12 (VSS), U1.P26 (VSS), U1.P31 (VSS), U1.P32 (VSS), U1.P35 (VSS), U1.R3 (VSS), U1.R4 (VSS), U1.R7 (VSS), U1.R12 (VSS), U1.R14 (VSS), U1.R15 (VSS), U1.R17 (VSS), U1.R19 (VSS), U1.R21 (VSS), U1.R23 (VSS), U1.R24 (VSS), U1.R26 (VSS), U1.R31 (VSS), U1.R34 (VSS), U1.R35 (VSS), U1.T1 (VSS), U1.T2 (VSS), U1.T3 (VSS), U1.T4 (VSS), U1.T5 (VSS), U1.T6 (VSS), U1.T7 (VSS), U1.T12 (VSS), U1.T26 (VSS), U1.T31 (VSS), U1.T32 (VSS), U1.T33 (VSS), U1.T34 (VSS), U1.T35 (VSS), U1.T36 (VSS), U1.T37 (VSS), U1.U5 (VSS), U1.U10 (VSS), U1.U12 (VSS), U1.U14 (VSS), U1.U16 (VSS), U1.U18 (VSS), U1.U20 (VSS), U1.U22 (VSS), U1.U24 (VSS), U1.U26 (VSS), U1.U28 (VSS), U1.U33 (VSS); also elsewhere on the board
/M2_RX0_N: U1.R32 (RXN[48]); also elsewhere on the board
/M2_RX0_P: U1.R33 (RXP[48]); also elsewhere on the board
/M2_RX1_N: U1.P33 (RXN[49]); also elsewhere on the board
/M2_RX1_P: U1.P34 (RXP[49]); also elsewhere on the board
/M2_RX2_N: U1.N32 (RXN[50]); also elsewhere on the board
/M2_RX2_P: U1.N33 (RXP[50]); also elsewhere on the board
/M2_RX3_N: U1.M33 (RXN[51]); also elsewhere on the board
/M2_RX3_P: U1.M34 (RXP[51]); also elsewhere on the board
/M2_TX0_N: U1.R36 (TXN[48]); also elsewhere on the board
/M2_TX0_P: U1.R37 (TXP[48]); also elsewhere on the board
/M2_TX1_N: U1.P36 (TXN[49]); also elsewhere on the board
/M2_TX1_P: U1.P37 (TXP[49]); also elsewhere on the board
/M2_TX2_N: U1.N36 (TXN[50]); also elsewhere on the board
/M2_TX2_P: U1.N37 (TXP[50]); also elsewhere on the board
/M2_TX3_N: U1.M36 (TXN[51]); also elsewhere on the board
/M2_TX3_P: U1.M37 (TXP[51]); also elsewhere on the board
/M3_RX0_N: U1.E34 (RXN[56]); also elsewhere on the board
/M3_RX0_P: U1.D34 (RXP[56]); also elsewhere on the board
/M3_RX1_N: U1.F33 (RXN[57]); also elsewhere on the board
/M3_RX1_P: U1.E33 (RXP[57]); also elsewhere on the board
/M3_RX2_N: U1.E32 (RXN[58]); also elsewhere on the board
/M3_RX2_P: U1.D32 (RXP[58]); also elsewhere on the board
/M3_RX3_N: U1.F31 (RXN[59]); also elsewhere on the board
/M3_RX3_P: U1.E31 (RXP[59]); also elsewhere on the board
/M3_TX0_N: U1.B34 (TXN[56]); also elsewhere on the board
/M3_TX1_N: U1.B33 (TXN[57]); also elsewhere on the board
/M3_TX2_N: U1.B32 (TXN[58]); also elsewhere on the board
/M3_TX3_N: U1.B31 (TXN[59]); also elsewhere on the board
/M4_RX0_N: U1.L32 (RXN[52]); also elsewhere on the board
/M4_RX0_P: U1.L33 (RXP[52]); also elsewhere on the board
/M4_RX1_N: U1.K33 (RXN[53]); also elsewhere on the board
/M4_RX1_P: U1.K34 (RXP[53]); also elsewhere on the board
/M4_RX2_N: U1.J32 (RXN[54]); also elsewhere on the board
/M4_RX2_P: U1.J33 (RXP[54]); also elsewhere on the board
/M4_RX3_N: U1.H33 (RXN[55]); also elsewhere on the board
/M4_RX3_P: U1.H34 (RXP[55]); also elsewhere on the board
/M4_TX0_N: U1.L36 (TXN[52]); also elsewhere on the board
/M4_TX0_P: U1.L37 (TXP[52]); also elsewhere on the board
/M4_TX1_N: U1.K36 (TXN[53]); also elsewhere on the board
/M4_TX1_P: U1.K37 (TXP[53]); also elsewhere on the board
/M4_TX2_N: U1.J36 (TXN[54]); also elsewhere on the board
/M4_TX2_P: U1.J37 (TXP[54]); also elsewhere on the board
/M4_TX3_N: U1.H36 (TXN[55]); also elsewhere on the board
/M4_TX3_P: U1.H37 (TXP[55]); also elsewhere on the board
/M5_RX0_N: U1.E30 (RXN[60]); also elsewhere on the board
/M5_RX0_P: U1.D30 (RXP[60]); also elsewhere on the board
/M5_RX1_N: U1.F29 (RXN[61]); also elsewhere on the board
/M5_RX1_P: U1.E29 (RXP[61]); also elsewhere on the board
/M5_RX2_N: U1.E28 (RXN[62]); also elsewhere on the board
/M5_RX2_P: U1.D28 (RXP[62]); also elsewhere on the board
/M5_RX3_N: U1.F27 (RXN[63]); also elsewhere on the board
/M5_RX3_P: U1.E27 (RXP[63]); also elsewhere on the board
/M5_TX0_N: U1.B30 (TXN[60]); also elsewhere on the board
/M5_TX1_N: U1.B29 (TXN[61]); also elsewhere on the board
/M5_TX2_N: U1.B28 (TXN[62]); also elsewhere on the board
/M5_TX3_N: U1.B27 (TXN[63]); also elsewhere on the board
/PEX_0V9: U1.U15 (VDD), U1.U17 (VDD), U1.U19 (VDD), U1.U21 (VDD), U1.U23 (VDD); also elsewhere on the board
/PEX_0V9A: U1.N14 (VDDA), U1.N16 (VDDA), U1.N18 (VDDA), U1.N20 (VDDA), U1.N22 (VDDA), U1.N24 (VDDA), U1.P13 (VDDA), U1.P15 (VDDA), U1.P17 (VDDA), U1.P19 (VDDA), U1.P21 (VDDA), U1.P23 (VDDA), U1.P25 (VDDA), U1.R13 (VDDA), U1.R16 (VDDA), U1.R18 (VDDA), U1.R20 (VDDA), U1.R22 (VDDA), U1.R25 (VDDA), U1.T13 (VDDA), U1.T15 (VDDA), U1.T17 (VDDA), U1.T19 (VDDA), U1.T21 (VDDA), U1.T23 (VDDA), U1.T25 (VDDA), U1.U13 (VDDA), U1.U25 (VDDA); also elsewhere on the board
/PEX_1V8: U1.P11 (VDD1x), U1.P14 (VDD1x), U1.P16 (VDD1x), U1.P18 (VDD1x), U1.P20 (VDD1x), U1.P22 (VDD1x), U1.P24 (VDD1x), U1.P27 (VDD1x), U1.T11 (VDD1x), U1.T14 (VDD1x), U1.T16 (VDD1x), U1.T18 (VDD1x), U1.T20 (VDD1x), U1.T22 (VDD1x), U1.T24 (VDD1x), U1.T27 (VDD1x), U1.U4 (VDD18), U1.U9 (VDD18), U1.U29 (VDD18), U1.U34 (VDD18); also elsewhere on the board
/PEX_1V8A: U1.N12 (VDD18A), U1.N15 (VDD1xA), U1.N17 (VDD1xA), U1.N19 (VDD1xA), U1.N21 (VDD1xA), U1.N23 (VDD1xA), U1.N26 (VDD18A), U1.R11 (VDD1xA), U1.R27 (VDD1xA), U1.U11 (VDD1xA), U1.U27 (VDD1xA); also elsewhere on the board
/PEX_MGMT_SCL_1V8: U1.C37 (I2C5_SCL)
/PEX_SPI_IO2: U1.P28 (SPI_SDIO[2]); also elsewhere on the board
/PEX_SPI_IO3: U1.N28 (SPI_SDIO[3]); also elsewhere on the board
/PEX_STRAP_DBG_MODE3: U1.N29 (DBG_MODE[3])
/PEX_STRAP_DFT_IDDT: U1.L28 (DFT_IDDT)
/PEX_STRAP_DFT_TN: U1.M28 (DFT_TN)
/PEX_STRAP_MODE_SEL5: U1.T29 (MODE_SEL[5])
/PEX_STRAP_MODE_SEL8: U1.R29 (MODE_SEL[8])
/PEX_STRAP_TRST_L: U1.U35 (TRST_L)
/PEX_SYS_RESET_N: U1.U31 (SYS_PWR_ON_RST_N); also elsewhere on the board
/S02_SW_TX0_N: U1.AY34 (TXN[8]); also elsewhere on the board
/S02_SW_TX0_P: U1.BA34 (TXP[8]); also elsewhere on the board
/S02_SW_TX1_N: U1.BA33 (TXN[9]); also elsewhere on the board
/S02_SW_TX1_P: U1.BB33 (TXP[9]); also elsewhere on the board
/S02_SW_TX2_N: U1.AY32 (TXN[10]); also elsewhere on the board
/S02_SW_TX2_P: U1.BA32 (TXP[10]); also elsewhere on the board
/S02_SW_TX3_N: U1.BA31 (TXN[11]); also elsewhere on the board
/S02_SW_TX3_P: U1.BB31 (TXP[11]); also elsewhere on the board
/S03_SW_TX0_N: U1.AY30 (TXN[12]); also elsewhere on the board
/S03_SW_TX0_P: U1.BA30 (TXP[12]); also elsewhere on the board
/S03_SW_TX1_N: U1.BA29 (TXN[13]); also elsewhere on the board
/S03_SW_TX1_P: U1.BB29 (TXP[13]); also elsewhere on the board
/S03_SW_TX2_N: U1.AY28 (TXN[14]); also elsewhere on the board
/S03_SW_TX2_P: U1.BA28 (TXP[14]); also elsewhere on the board
/S03_SW_TX3_N: U1.BA27 (TXN[15]); also elsewhere on the board
/S03_SW_TX3_P: U1.BB27 (TXP[15]); also elsewhere on the board
/S04_SW_TX0_N: U1.AY26 (TXN[16]); also elsewhere on the board
/S04_SW_TX0_P: U1.BA26 (TXP[16]); also elsewhere on the board
/S04_SW_TX1_N: U1.BA25 (TXN[17]); also elsewhere on the board
/S04_SW_TX1_P: U1.BB25 (TXP[17]); also elsewhere on the board
/S04_SW_TX2_N: U1.AY24 (TXN[18]); also elsewhere on the board
/S04_SW_TX2_P: U1.BA24 (TXP[18]); also elsewhere on the board
/S04_SW_TX3_N: U1.BA23 (TXN[19]); also elsewhere on the board
/S04_SW_TX3_P: U1.BB23 (TXP[19]); also elsewhere on the board
/S05_SW_TX0_N: U1.AY22 (TXN[20]); also elsewhere on the board
/S05_SW_TX0_P: U1.BA22 (TXP[20]); also elsewhere on the board
/S05_SW_TX1_N: U1.BA21 (TXN[21]); also elsewhere on the board
/S05_SW_TX1_P: U1.BB21 (TXP[21]); also elsewhere on the board
/S05_SW_TX2_N: U1.AY20 (TXN[22]); also elsewhere on the board
/S05_SW_TX2_P: U1.BA20 (TXP[22]); also elsewhere on the board
/S05_SW_TX3_N: U1.BA19 (TXN[23]); also elsewhere on the board
/S05_SW_TX3_P: U1.BB19 (TXP[23]); also elsewhere on the board
/S06_SW_TX0_N: U1.AY18 (TXN[24]); also elsewhere on the board
/S06_SW_TX0_P: U1.BA18 (TXP[24]); also elsewhere on the board
/S06_SW_TX1_N: U1.BA17 (TXN[25]); also elsewhere on the board
/S06_SW_TX1_P: U1.BB17 (TXP[25]); also elsewhere on the board
/S06_SW_TX2_N: U1.AY16 (TXN[26]); also elsewhere on the board
/S06_SW_TX2_P: U1.BA16 (TXP[26]); also elsewhere on the board
/S06_SW_TX3_N: U1.BA15 (TXN[27]); also elsewhere on the board
/S06_SW_TX3_P: U1.BB15 (TXP[27]); also elsewhere on the board
/S07_SW_TX0_N: U1.AY14 (TXN[28]); also elsewhere on the board
/S07_SW_TX0_P: U1.BA14 (TXP[28]); also elsewhere on the board
/S07_SW_TX1_N: U1.BA13 (TXN[29]); also elsewhere on the board
/S07_SW_TX1_P: U1.BB13 (TXP[29]); also elsewhere on the board
/S07_SW_TX2_N: U1.AY12 (TXN[30]); also elsewhere on the board
/S07_SW_TX2_P: U1.BA12 (TXP[30]); also elsewhere on the board
/S07_SW_TX3_N: U1.BA11 (TXN[31]); also elsewhere on the board
/S07_SW_TX3_P: U1.BB11 (TXP[31]); also elsewhere on the board
/S08_SW_TX0_N: U1.AY10 (TXN[32]); also elsewhere on the board
/S08_SW_TX0_P: U1.BA10 (TXP[32]); also elsewhere on the board
/S08_SW_TX1_N: U1.BA9 (TXN[33]); also elsewhere on the board
/S08_SW_TX1_P: U1.BB9 (TXP[33]); also elsewhere on the board
/S08_SW_TX2_N: U1.AY8 (TXN[34]); also elsewhere on the board
/S08_SW_TX2_P: U1.BA8 (TXP[34]); also elsewhere on the board
/S08_SW_TX3_N: U1.BA7 (TXN[35]); also elsewhere on the board
/S08_SW_TX3_P: U1.BB7 (TXP[35]); also elsewhere on the board
/S09_SW_TX0_N: U1.AY6 (TXN[36]); also elsewhere on the board
/S09_SW_TX0_P: U1.BA6 (TXP[36]); also elsewhere on the board
/S09_SW_TX1_N: U1.BA5 (TXN[37]); also elsewhere on the board
/S09_SW_TX1_P: U1.BB5 (TXP[37]); also elsewhere on the board
/S09_SW_TX2_N: U1.AY4 (TXN[38]); also elsewhere on the board
/S09_SW_TX2_P: U1.BA4 (TXP[38]); also elsewhere on the board
/S09_SW_TX3_N: U1.BA3 (TXN[39]); also elsewhere on the board
/S09_SW_TX3_P: U1.BB3 (TXP[39]); also elsewhere on the board
/UP_RX0_N: U1.H26 (RXN[64]); also elsewhere on the board
/UP_RX0_P: U1.G26 (RXP[64]); also elsewhere on the board
/UP_RX1_N: U1.F25 (RXN[65]); also elsewhere on the board
/UP_RX1_P: U1.E25 (RXP[65]); also elsewhere on the board
/UP_RX2_N: U1.H24 (RXN[66]); also elsewhere on the board
/UP_RX2_P: U1.G24 (RXP[66]); also elsewhere on the board
/UP_RX3_N: U1.F23 (RXN[67]); also elsewhere on the board
/UP_RX3_P: U1.E23 (RXP[67]); also elsewhere on the board
/UP_TX0_N: U1.B26 (TXN[64]); also elsewhere on the board
/UP_TX1_N: U1.C25 (TXN[65]); also elsewhere on the board
/UP_TX1_P: U1.B25 (TXP[65]); also elsewhere on the board
/UP_TX2_N: U1.B24 (TXN[66]); also elsewhere on the board
/UP_TX3_N: U1.C23 (TXN[67]); also elsewhere on the board
/UP_TX3_P: U1.B23 (TXP[67]); also elsewhere on the board

Schematic: Connectivity_03.kicad_sch, Main_10E1S / Connectivity 03

Parts:
C1, C2: 10uF 25V X7R; C_1210_3225Metric
C101, C104, C107: 10nF 25V; C_0402_1005Metric
C102, C105, C108: 100nF 50V; C_0603_1608Metric
C103, C106: 1uF 25V; C_0603_1608Metric
U1: Broadcom PEX88096 / SS02-0B00-00; Broadcom_PEX88096_BGA1550_37p5x42p5_1mm

Connections:
/GND: C1.2, C2.2, C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, U1.V4 (VSS), U1.V9 (VSS), U1.V12 (VSS), U1.V15 (VSS), U1.V17 (VSS), U1.V19 (VSS), U1.V21 (VSS), U1.V23 (VSS), U1.V26 (VSS), U1.V29 (VSS), U1.V34 (VSS), U1.W1 (VSS), U1.W2 (VSS), U1.W3 (VSS), U1.W4 (VSS), U1.W5 (VSS), U1.W6 (VSS), U1.W7 (VSS), U1.W10 (VSS), U1.W12 (VSS), U1.W13 (VSS), U1.W14 (VSS), U1.W16 (VSS), U1.W18 (VSS), U1.W20 (VSS), U1.W22 (VSS), U1.W24 (VSS), U1.W26 (VSS), U1.W28 (VSS), U1.W33 (VSS), U1.Y3 (VSS), U1.Y4 (VSS), U1.Y7 (VSS), U1.Y9 (VSS), U1.Y11 (VSS), U1.Y15 (VSS), U1.Y17 (VSS), U1.Y19 (VSS), U1.Y21 (VSS), U1.Y23 (VSS), U1.Y25 (VSS), U1.Y26 (VSS), U1.Y27 (VSS), U1.Y29 (VSS), U1.Y34 (VSS); also elsewhere on the board
/P12_SLOT01: C103.1; also elsewhere on the board
/P12_SLOT02: C106.1; also elsewhere on the board
/PEX_0V9: U1.V14 (VDD), U1.V16 (VDD), U1.V18 (VDD), U1.V20 (VDD), U1.V22 (VDD), U1.V24 (VDD), U1.W15 (VDD), U1.W17 (VDD), U1.W19 (VDD), U1.W21 (VDD), U1.W23 (VDD), U1.W25 (VDD), U1.Y14 (VDD), U1.Y16 (VDD), U1.Y18 (VDD), U1.Y20 (VDD), U1.Y22 (VDD), U1.Y24 (VDD); also elsewhere on the board
/PEX_0V9A: U1.V13 (VDDA), U1.V25 (VDDA); also elsewhere on the board
/PEX_1V8: U1.V5 (VDD18), U1.V10 (VDD18), U1.V11 (VDD1x), U1.V27 (VDD1x), U1.V28 (VDD18), U1.V33 (VDD18), U1.W9 (VDD18), U1.W29 (VDD18), U1.W34 (VDD18), U1.Y10 (VDD18), U1.Y28 (VDD18), U1.Y33 (VDD18); also elsewhere on the board
/PEX_1V8A: U1.W11 (VDD1xA), U1.W27 (VDD1xA), U1.Y12 (VDD18A), U1.Y13 (VDD18A); also elsewhere on the board
/PEX_MGMT_SDA_1V8: U1.Y36 (I2C5_SDA)
/PEX_SPI_IO0: U1.Y30 (SPI_SDIO[0]); also elsewhere on the board
/PEX_SPI_IO1: U1.Y31 (SPI_SDIO[1]); also elsewhere on the board
/PEX_STRAP_DFT_SCAN_ENABLE: U1.V32 (DFT_SCAN_ENABLE)
/PEX_STRAP_DFT_SHIFT_CLK: U1.V35 (DFT_SHIFT_CLK)
/S01_PWR_DVDT: C101.1; also elsewhere on the board
/S02_PWR_DVDT: C104.1; also elsewhere on the board
/S03_PWR_DVDT: C107.1; also elsewhere on the board
/VBANK_A: C1.1, C102.1, C105.1, C108.1; also elsewhere on the board
/VBANK_B: C2.1; also elsewhere on the board

Schematic: Connectivity_04.kicad_sch, Main_10E1S / Connectivity 04

Parts:
C109, C112, C115, C118: 1uF 25V; C_0603_1608Metric
C110, C113, C116, C119: 10nF 25V; C_0402_1005Metric
C111, C114, C117, C120: 100nF 50V; C_0603_1608Metric

Connections:
/GND: C109.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, C116.2, C117.2, C118.2, C119.2, C120.2; also elsewhere on the board
/P12_SLOT03: C109.1; also elsewhere on the board
/P12_SLOT04: C112.1; also elsewhere on the board
/P12_SLOT05: C115.1; also elsewhere on the board
/P12_SLOT06: C118.1; also elsewhere on the board
/S04_PWR_DVDT: C110.1; also elsewhere on the board
/S05_PWR_DVDT: C113.1; also elsewhere on the board
/S06_PWR_DVDT: C116.1; also elsewhere on the board
/S07_PWR_DVDT: C119.1; also elsewhere on the board
/VBANK_A: C111.1, C114.1; also elsewhere on the board
/VBANK_B: C117.1, C120.1; also elsewhere on the board

Schematic: Connectivity_05.kicad_sch, Main_10E1S / Connectivity 05

Parts:
C121, C124, C127, C130: 1uF 25V; C_0603_1608Metric
C122, C125, C128, C301: 10nF 25V; C_0402_1005Metric
C123, C126, C129: 100nF 50V; C_0603_1608Metric
C311: 10uF 25V; C_0805_2012Metric

Connections:
/AUX_12V_PROTECTED: C311.1; also elsewhere on the board
/AUX_DVDT: C301.1; also elsewhere on the board
/GND: C121.2, C122.2, C123.2, C124.2, C125.2, C126.2, C127.2, C128.2, C129.2, C130.2, C301.2, C311.2; also elsewhere on the board
/P12_SLOT07: C121.1; also elsewhere on the board
/P12_SLOT08: C124.1; also elsewhere on the board
/P12_SLOT09: C127.1; also elsewhere on the board
/P12_SLOT10: C130.1; also elsewhere on the board
/S08_PWR_DVDT: C122.1; also elsewhere on the board
/S09_PWR_DVDT: C125.1; also elsewhere on the board
/S10_PWR_DVDT: C128.1; also elsewhere on the board
/VBANK_B: C123.1, C126.1, C129.1; also elsewhere on the board

Schematic: Connectivity_06.kicad_sch, Main_10E1S / Connectivity 06

Parts:
C312: 100nF 50V; C_0402_1005Metric
C313: 3.3nF 25V; C_0402_1005Metric
C314, C315: 47uF 16V; C_1210_3225Metric
C411, C421: 10nF; C_0402_1005Metric
C412, C422: 100nF 50V; C_0603_1608Metric
D1, D2: SMBJ13CA; D_SMB
F1, F2: 20A 125V; Littelfuse_456_20A

Connections:
/AUX_12V_PROTECTED: C312.1; also elsewhere on the board
/BUCK_SS: C313.1; also elsewhere on the board
/EXT_41_DVDT: C411.1; also elsewhere on the board
/EXT_42_DVDT: C421.1; also elsewhere on the board
/GND: C312.2, C313.2, C314.2, C315.2, C411.2, C412.2, C421.2, C422.2, D1.2, D2.2; also elsewhere on the board
/P3V3_AUX: C314.1, C315.1; also elsewhere on the board
/VBANK_A: D1.1, F1.2; also elsewhere on the board
/VBANK_B: D2.1, F2.2; also elsewhere on the board
/VIN_A: C412.1, F1.1; also elsewhere on the board
/VIN_B: C422.1, F2.1; also elsewhere on the board
