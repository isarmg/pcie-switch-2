# Repository isarmg/pcie-switch-2 (continued)

## KiCad design outputs/PCIe_3board_RevL/Main_10E1S/Main_10E1S.kicad_pcb (continued)

Schematic: Connectivity_31.kicad_sch, Main_10E1S / Connectivity 31

Parts:
U31: TPS62132RGTR; VQFN-16-1EP_3x3mm_P0.5mm_EP1.68x1.68mm
U41, U42: TPS259470ARPWR; TI_RPW0010A_TPS25947
U502: Intel Core Ultra 7 268V / BGA2833; Intel_Core_Ultra_200V_BGA2833_27p5x27_ExactXY_DraftLands

Connections:
/AUX_12V_PROTECTED: U31.10, U31.11, U31.12, U31.13; also elsewhere on the board
/AUX_PG: U31.4; also elsewhere on the board
/BUCK_SS: U31.9; also elsewhere on the board
/BUCK_SW: U31.1, U31.2, U31.3; also elsewhere on the board
/CABLE12_L: U41.6; also elsewhere on the board
/CABLE12_R: U42.6; also elsewhere on the board
/CPU_EPD_ON_LOOP_1V25: U502.AB27 (EPD_ON_OUT); also elsewhere on the board
/CPU_RTCX1: U502.A12 (RTCX1); also elsewhere on the board
/CPU_RTCX2: U502.A10 (RTCX2); also elsewhere on the board
/CPU_SPI_CS0_N: U502.AC17 (SPI0_CS0#); also elsewhere on the board
/CPU_SPI_IO0: U502.AA17 (SPI0_MOSI); also elsewhere on the board
/CPU_SPI_IO1: U502.AE17 (SPI0_MISO); also elsewhere on the board
/CPU_V1P8U_MEM: U502.AK67 (V1P8U_MEM), U502.AK70 (V1P8U_MEM), U502.AL69 (V1P8U_MEM), U502.AM67 (V1P8U_MEM), U502.AM70 (V1P8U_MEM), U502.AP67 (V1P8U_MEM), U502.AP70 (V1P8U_MEM), U502.AR69 (V1P8U_MEM), U502.AT67 (V1P8U_MEM), U502.AT70 (V1P8U_MEM), U502.AT73 (V1P8U_MEM), U502.AT76 (V1P8U_MEM), U502.AT79 (V1P8U_MEM); also elsewhere on the board
/CPU_V1P8U_MEM_EDGECAP_1: U502.AE92 (V1P8U_MEM_EDGECAP_1), U502.AG92 (V1P8U_MEM_EDGECAP_1); also elsewhere on the board
/CPU_VCCGT: U502.A34 (VCCGT), U502.A36 (VCCGT), U502.A38 (VCCGT), U502.A40 (VCCGT), U502.A42 (VCCGT), U502.A44 (VCCGT), U502.A46 (VCCGT), U502.A48 (VCCGT), U502.A50 (VCCGT), U502.A52 (VCCGT), U502.A54 (VCCGT), U502.A56 (VCCGT), U502.A58 (VCCGT), U502.A60 (VCCGT), U502.A88 (VCCGT), U502.A90 (VCCGT), U502.AA34 (VCCGT), U502.AA40 (VCCGT), U502.AA46 (VCCGT), U502.AA51 (VCCGT), U502.AA57 (VCCGT), U502.AA63 (VCCGT), U502.AA69 (VCCGT), U502.AA75 (VCCGT), U502.AA80 (VCCGT), U502.AA86 (VCCGT), U502.AB30 (VCCGT), U502.AB33 (VCCGT), U502.AB36 (VCCGT), U502.AB38 (VCCGT), U502.AB41 (VCCGT), U502.AB44 (VCCGT), U502.AB47 (VCCGT), U502.AB50 (VCCGT), U502.AB53 (VCCGT), U502.AB56 (VCCGT), U502.AB59 (VCCGT), U502.AB62 (VCCGT), U502.AB64 (VCCGT), U502.AB67 (VCCGT), U502.AB70 (VCCGT), U502.AB73 (VCCGT), U502.AB76 (VCCGT), U502.AB79 (VCCGT), U502.AB82 (VCCGT), U502.AB85 (VCCGT), U502.AB88 (VCCGT), U502.AB90 (VCCGT), U502.AB93 (VCCGT), U502.AC31 (VCCGT), U502.AC34 (VCCGT), U502.AC37 (VCCGT), U502.AC40 (VCCGT), U502.AC43 (VCCGT), U502.AC46 (VCCGT), U502.AC49 (VCCGT), U502.AC51 (VCCGT), U502.AC54 (VCCGT), U502.AC57 (VCCGT), U502.AC60 (VCCGT), U502.AC63 (VCCGT), U502.AC66 (VCCGT), U502.AC69 (VCCGT), U502.AC72 (VCCGT), U502.AC75 (VCCGT), U502.AC77 (VCCGT), U502.AC80 (VCCGT), U502.AC83 (VCCGT), U502.AC86 (VCCGT), U502.AC89 (VCCGT), U502.AC92 (VCCGT), U502.AD30 (VCCGT), U502.AD33 (VCCGT), U502.AD36 (VCCGT), U502.AD38 (VCCGT), U502.AD41 (VCCGT), U502.AD44 (VCCGT), U502.AD47 (VCCGT), U502.AD50 (VCCGT), U502.AD53 (VCCGT), U502.AD56 (VCCGT), U502.AD59 (VCCGT), U502.AD62 (VCCGT), U502.AD64 (VCCGT), U502.AD67 (VCCGT), U502.AD70 (VCCGT), U502.AD73 (VCCGT), U502.AD76 (VCCGT), U502.AD79 (VCCGT), U502.AD82 (VCCGT), U502.AD85 (VCCGT), U502.AD88 (VCCGT), U502.AD90 (VCCGT), U502.AD93 (VCCGT), U502.AE31 (VCCGT), U502.AE37 (VCCGT), U502.AE43 (VCCGT), U502.AE49 (VCCGT), U502.AE54 (VCCGT), U502.AE60 (VCCGT), U502.AE66 (VCCGT), U502.AE72 (VCCGT), U502.AE77 (VCCGT), U502.AE83 (VCCGT), U502.AE89 (VCCGT), U502.AF30 (VCCGT), U502.AF33 (VCCGT), U502.AF36 (VCCGT), U502.AF38 (VCCGT), U502.AF41 (VCCGT), U502.AF44 (VCCGT), U502.AF47 (VCCGT), U502.AF50 (VCCGT), U502.AF53 (VCCGT), U502.AF56 (VCCGT), U502.AF59 (VCCGT), U502.AF62 (VCCGT), U502.AF64 (VCCGT), U502.AF67 (VCCGT), U502.AF70 (VCCGT), U502.AF73 (VCCGT), U502.AF76 (VCCGT), U502.AF79 (VCCGT), U502.AF82 (VCCGT), U502.AF85 (VCCGT), U502.AF88 (VCCGT), U502.AG31 (VCCGT), U502.AG34 (VCCGT), U502.AG37 (VCCGT), U502.AG40 (VCCGT), U502.AG43 (VCCGT), U502.AG46 (VCCGT), U502.AG49 (VCCGT), U502.AG51 (VCCGT), U502.AG54 (VCCGT), U502.AG57 (VCCGT), U502.AG60 (VCCGT), U502.AG63 (VCCGT), U502.AG66 (VCCGT), U502.AG69 (VCCGT), U502.AG72 (VCCGT), U502.AG80 (VCCGT), U502.AG83 (VCCGT), U502.AG86 (VCCGT), U502.AG89 (VCCGT), U502.AH30 (VCCGT), U502.AH33 (VCCGT), U502.AH36 (VCCGT), U502.AH38 (VCCGT), U502.AH41 (VCCGT), U502.AH44 (VCCGT), U502.AH47 (VCCGT), U502.AH50 (VCCGT), U502.AH53 (VCCGT), U502.AH56 (VCCGT), U502.AH59 (VCCGT), U502.AH62 (VCCGT), U502.AH64 (VCCGT)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; also elsewhere on the board
/CPU_VCCPRIM_1P8: U502.AR20 (VCCPRIM_1P8), U502.AR23 (VCCPRIM_1P8), U502.AR26 (VCCPRIM_1P8), U502.AT21 (VCCPRIM_1P8), U502.AT24 (VCCPRIM_1P8); also elsewhere on the board
/CPU_VCCPRIM_1P8_FLTRB_IN: U502.AR17 (VCCPRIM_1P8_FLTRB_IN), U502.AT18 (VCCPRIM_1P8_FLTRB_IN); also elsewhere on the board
/CPU_VCCRTC: U502.AN20 (VCCRTC); also elsewhere on the board
/CPU_VDD2L: U502.AL72 (VDD2L), U502.AL80 (VDD2L), U502.AL83 (VDD2L), U502.AL86 (VDD2L), U502.AL89 (VDD2L), U502.AL92 (VDD2L), U502.AM73 (VDD2L), U502.AM76 (VDD2L), U502.AM79 (VDD2L), U502.AM82 (VDD2L), U502.AM85 (VDD2L), U502.AM88 (VDD2L), U502.AN72 (VDD2L), U502.AN77 (VDD2L), U502.AN83 (VDD2L), U502.AN89 (VDD2L), U502.AN92 (VDD2L), U502.AP73 (VDD2L), U502.AP76 (VDD2L), U502.AP79 (VDD2L), U502.AP82 (VDD2L), U502.AP85 (VDD2L), U502.AP88 (VDD2L), U502.AR72 (VDD2L), U502.AR75 (VDD2L), U502.AR77 (VDD2L), U502.AR80 (VDD2L), U502.AR83 (VDD2L), U502.AR86 (VDD2L), U502.AR89 (VDD2L), U502.AR92 (VDD2L); also elsewhere on the board
/CPU_VDD2_PWRGOOD_LOOP: U502.AA26 (VDD2PWRGOOD_IN), U502.AC26 (VDD2PWRGOOD_OUT)
/CPU_VDDQ: U502.AT82 (VDDQ), U502.AT85 (VDDQ); also elsewhere on the board
/CPU_VDDRIO: U502.AR57 (VDDRIO), U502.AR60 (VDDRIO), U502.AR63 (VDDRIO), U502.AR66 (VDDRIO), U502.AT59 (VDDRIO), U502.AT62 (VDDRIO), U502.AT64 (VDDRIO); also elsewhere on the board
/EXT_41_DVDT: U41.7; also elsewhere on the board
/EXT_41_ILM: U41.9; also elsewhere on the board
/EXT_41_OV: U41.2; also elsewhere on the board
/EXT_41_UV: U41.1; also elsewhere on the board
/EXT_42_DVDT: U42.7; also elsewhere on the board
/EXT_42_ILM: U42.9; also elsewhere on the board
/EXT_42_OV: U42.2; also elsewhere on the board
/EXT_42_UV: U42.1; also elsewhere on the board
/GND: U31.5, U31.6, U31.7, U31.8, U31.15, U31.16, U31.17, U41.8, U42.8, U502.A4 (VSS), U502.A6 (VSS), U502.A8 (VSS), U502.A14 (VSS), U502.A32 (VSS), U502.A62 (VSS), U502.A64 (VSS), U502.A66 (VSS), U502.A68 (VSS), U502.A70 (VSS), U502.A72 (VSS), U502.A74 (VSS), U502.A76 (VSS), U502.A78 (VSS), U502.A80 (VSS), U502.A82 (VSS), U502.A84 (VSS), U502.A86 (VSS), U502.AA2 (VSS), U502.AA4 (VSS), U502.AA20 (VSS), U502.AA23 (VSS), U502.AA28 (VSS), U502.AA31 (VSS), U502.AA37 (VSS), U502.AA43 (VSS), U502.AA49 (VSS), U502.AA54 (VSS), U502.AA60 (VSS), U502.AA66 (VSS), U502.AA72 (VSS), U502.AA77 (VSS), U502.AA83 (VSS), U502.AA89 (VSS), U502.AA92 (VSS), U502.AB1 (VSS), U502.AB6 (VSS), U502.AB11 (VSS), U502.AB15 (VSS), U502.AB18 (VSS), U502.AB21 (VSS), U502.AB24 (VSS), U502.AC2 (VSS), U502.AC20 (VSS), U502.AC23 (VSS), U502.AC28 (VSS), U502.AD6 (VSS), U502.AD11 (VSS), U502.AD15 (VSS), U502.AD18 (VSS), U502.AD21 (VSS), U502.AD24 (VSS), U502.AD27 (VSS), U502.AE20 (VSS), U502.AE23 (VSS), U502.AE26 (VSS), U502.AE28 (VSS), U502.AE34 (VSS), U502.AE40 (VSS), U502.AE46 (VSS), U502.AE51 (VSS), U502.AE57 (VSS), U502.AE63 (VSS), U502.AE69 (VSS), U502.AE75 (VSS), U502.AE80 (VSS), U502.AE86 (VSS), U502.AF7 (VSS), U502.AF15 (VSS), U502.AF18 (VSS), U502.AF21 (VSS), U502.AF24 (VSS), U502.AF27 (VSS), U502.AF90 (VSS), U502.AF93 (VSS), U502.AG1 (VSS), U502.AG3 (VSS), U502.AG6 (VSS), U502.AG8 (VSS), U502.AG11 (VSS), U502.AG17 (VSS), U502.AG20 (VSS), U502.AG23 (VSS), U502.AG26 (VSS), U502.AG28 (VSS), U502.AH7 (VSS), U502.AH9 (VSS), U502.AH15 (VSS), U502.AH18 (VSS), U502.AH21 (VSS), U502.AH24 (VSS), U502.AH27 (VSS), U502.AH93 (VSS), U502.AJ6 (VSS), U502.AJ11 (VSS), U502.AJ17 (VSS), U502.AJ20 (VSS), U502.AJ23 (VSS), U502.AJ26 (VSS), U502.AJ28 (VSS), U502.AJ31 (VSS), U502.AJ37 (VSS), U502.AJ43 (VSS), U502.AJ49 (VSS), U502.AJ54 (VSS), U502.AJ60 (VSS), U502.AJ66 (VSS), U502.AJ72 (VSS), U502.AJ83 (VSS), U502.AK2 (VSS), U502.AK4 (VSS), U502.AK7 (VSS), U502.AK12 (VSS), U502.AK15 (VSS), U502.AK18 (VSS), U502.AK21 (VSS), U502.AK24 (VSS), U502.AK27 (VSS), U502.AK93 (VSS), U502.AL17 (VSS), U502.AL20 (VSS), U502.AL23 (VSS), U502.AL26 (VSS), U502.AL28 (VSS), U502.AM6 (VSS), U502.AM8 (VSS), U502.AM13 (VSS), U502.AM15 (VSS), U502.AM18 (VSS), U502.AM21 (VSS), U502.AM24 (VSS), U502.AM27 (VSS), U502.AM90 (VSS), U502.AM93 (VSS), U502.AN9 (VSS), U502.AN17 (VSS), U502.AN23 (VSS), U502.AN26 (VSS), U502.AN28 (VSS), U502.AN34 (VSS), U502.AN40 (VSS), U502.AN46 (VSS), U502.AN51 (VSS), U502.AN57 (VSS), U502.AN63 (VSS), U502.AN69 (VSS), U502.AN75 (VSS), U502.AN80 (VSS), U502.AN86 (VSS)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; also elsewhere on the board
/P3V3_AUX: U31.14; also elsewhere on the board
/VIN_A: U41.5; also elsewhere on the board
/VIN_B: U42.5; also elsewhere on the board

Schematic: Connectivity_32.kicad_sch, Main_10E1S / Connectivity 32

Parts:
U502: Intel Core Ultra 7 268V / BGA2833; Intel_Core_Ultra_200V_BGA2833_27p5x27_ExactXY_DraftLands

Connections:
/CPU_CLKBUF1_IN_N: U502.BC2 (CLKOUT_N1); also elsewhere on the board
/CPU_CLKBUF1_IN_P: U502.BB1 (CLKOUT_P1); also elsewhere on the board
/CPU_CLKBUF2_IN_N: U502.AY4 (CLKOUT_N2); also elsewhere on the board
/CPU_CLKBUF2_IN_P: U502.AW3 (CLKOUT_P2); also elsewhere on the board
/CPU_CLKREQ0_N: U502.B55 (GPP_C09); also elsewhere on the board
/CPU_CLK_RCOMP: U502.BG3 (CLK_S_RCOMP); also elsewhere on the board
/CPU_REFCLK_N: U502.BC4 (CLKOUT_N0); also elsewhere on the board
/CPU_REFCLK_P: U502.BB3 (CLKOUT_P0); also elsewhere on the board
/CPU_SRTCRST_N: U502.B15 (SRTCRST#); also elsewhere on the board
/CPU_USB32_RCOMP: U502.BG1 (USB32_RCOMP); also elsewhere on the board
/CPU_V1P8U_MEM: U502.AU69 (V1P8U_MEM), U502.AU75 (V1P8U_MEM), U502.AU80 (V1P8U_MEM), U502.AV67 (V1P8U_MEM), U502.AV70 (V1P8U_MEM), U502.AV73 (V1P8U_MEM), U502.AV76 (V1P8U_MEM), U502.AV79 (V1P8U_MEM), U502.AW69 (V1P8U_MEM), U502.AW72 (V1P8U_MEM), U502.AW75 (V1P8U_MEM), U502.AW77 (V1P8U_MEM), U502.AW80 (V1P8U_MEM), U502.AY67 (V1P8U_MEM), U502.AY70 (V1P8U_MEM), U502.AY73 (V1P8U_MEM), U502.AY76 (V1P8U_MEM), U502.AY79 (V1P8U_MEM), U502.BA72 (V1P8U_MEM), U502.BA77 (V1P8U_MEM), U502.BB67 (V1P8U_MEM), U502.BB70 (V1P8U_MEM), U502.BB73 (V1P8U_MEM), U502.BB76 (V1P8U_MEM), U502.BB79 (V1P8U_MEM), U502.BC69 (V1P8U_MEM), U502.BC77 (V1P8U_MEM), U502.BC80 (V1P8U_MEM), U502.BD67 (V1P8U_MEM), U502.BD79 (V1P8U_MEM), U502.BD82 (V1P8U_MEM), U502.BD85 (V1P8U_MEM), U502.BD88 (V1P8U_MEM), U502.BD90 (V1P8U_MEM), U502.BD93 (V1P8U_MEM), U502.BE69 (V1P8U_MEM), U502.BE80 (V1P8U_MEM), U502.BE86 (V1P8U_MEM), U502.BF67 (V1P8U_MEM), U502.BF79 (V1P8U_MEM), U502.BF82 (V1P8U_MEM), U502.BF85 (V1P8U_MEM), U502.BF88 (V1P8U_MEM), U502.BF90 (V1P8U_MEM), U502.BF93 (V1P8U_MEM), U502.BG69 (V1P8U_MEM), U502.BG77 (V1P8U_MEM), U502.BG80 (V1P8U_MEM), U502.BG83 (V1P8U_MEM), U502.BG86 (V1P8U_MEM), U502.BG89 (V1P8U_MEM), U502.BG92 (V1P8U_MEM), U502.BH67 (V1P8U_MEM), U502.BH79 (V1P8U_MEM), U502.BH82 (V1P8U_MEM), U502.BH85 (V1P8U_MEM), U502.BH88 (V1P8U_MEM), U502.BH90 (V1P8U_MEM), U502.BH93 (V1P8U_MEM), U502.BJ77 (V1P8U_MEM), U502.BK67 (V1P8U_MEM), U502.BK79 (V1P8U_MEM), U502.BL69 (V1P8U_MEM), U502.BL72 (V1P8U_MEM), U502.BL77 (V1P8U_MEM), U502.BL80 (V1P8U_MEM), U502.BM67 (V1P8U_MEM), U502.BM70 (V1P8U_MEM), U502.BM73 (V1P8U_MEM), U502.BM76 (V1P8U_MEM), U502.BM79 (V1P8U_MEM), U502.BN69 (V1P8U_MEM), U502.BN75 (V1P8U_MEM), U502.BN80 (V1P8U_MEM), U502.BP67 (V1P8U_MEM), U502.BP70 (V1P8U_MEM), U502.BP73 (V1P8U_MEM), U502.BP76 (V1P8U_MEM), U502.BP79 (V1P8U_MEM), U502.BR69 (V1P8U_MEM), U502.BR72 (V1P8U_MEM), U502.BR75 (V1P8U_MEM), U502.BR77 (V1P8U_MEM), U502.BR80 (V1P8U_MEM), U502.BT67 (V1P8U_MEM), U502.BT70 (V1P8U_MEM), U502.BT73 (V1P8U_MEM), U502.BT76 (V1P8U_MEM), U502.BT79 (V1P8U_MEM); also elsewhere on the board
/CPU_V1P8U_MEM_EDGECAP_0: U502.B69 (V1P8U_MEM_EDGECAP_0), U502.B71 (V1P8U_MEM_EDGECAP_0); also elsewhere on the board
/CPU_VCCGT: U502.B88 (VCCGT), U502.B92 (VCCGT); also elsewhere on the board
/CPU_VCCL2: U502.BV41 (VCCL2), U502.BV44 (VCCL2), U502.BV47 (VCCL2); also elsewhere on the board
/CPU_VCCPRIM_1P8: U502.AU20 (VCCPRIM_1P8), U502.AU23 (VCCPRIM_1P8), U502.AU26 (VCCPRIM_1P8); also elsewhere on the board
/CPU_VCCPRIM_1P8_FLTRA_IN: U502.BJ20 (VCCPRIM_1P8_FLTRA_IN), U502.BL20 (VCCPRIM_1P8_FLTRA_IN), U502.BN20 (VCCPRIM_1P8_FLTRA_IN); also elsewhere on the board
/CPU_VCCPRIM_1P8_FLTRB_IN: U502.AU17 (VCCPRIM_1P8_FLTRB_IN); also elsewhere on the board
/CPU_VCCPRIM_3P3: U502.AW17 (VCCPRIM_3P3), U502.BA17 (VCCPRIM_3P3); also elsewhere on the board
/CPU_VCCPRIM_IO: U502.BB18 (VCCPRIM_IO), U502.BC17 (VCCPRIM_IO), U502.BD18 (VCCPRIM_IO), U502.BE17 (VCCPRIM_IO), U502.BF18 (VCCPRIM_IO), U502.BG17 (VCCPRIM_IO), U502.BH18 (VCCPRIM_IO), U502.BJ17 (VCCPRIM_IO), U502.BK18 (VCCPRIM_IO), U502.BL17 (VCCPRIM_IO), U502.BM18 (VCCPRIM_IO), U502.BN17 (VCCPRIM_IO), U502.BP18 (VCCPRIM_IO), U502.BR17 (VCCPRIM_IO), U502.BT18 (VCCPRIM_IO), U502.BU17 (VCCPRIM_IO), U502.BV18 (VCCPRIM_IO); also elsewhere on the board
/CPU_VCCPRIM_VNNAON: U502.AW20 (VCCPRIM_VNNAON), U502.AW23 (VCCPRIM_VNNAON), U502.AW26 (VCCPRIM_VNNAON), U502.AY21 (VCCPRIM_VNNAON), U502.AY24 (VCCPRIM_VNNAON), U502.AY27 (VCCPRIM_VNNAON), U502.BA20 (VCCPRIM_VNNAON), U502.BA26 (VCCPRIM_VNNAON), U502.BB21 (VCCPRIM_VNNAON), U502.BB24 (VCCPRIM_VNNAON), U502.BB27 (VCCPRIM_VNNAON), U502.BC20 (VCCPRIM_VNNAON), U502.BC23 (VCCPRIM_VNNAON), U502.BC26 (VCCPRIM_VNNAON), U502.BD21 (VCCPRIM_VNNAON), U502.BD24 (VCCPRIM_VNNAON), U502.BD27 (VCCPRIM_VNNAON), U502.BE23 (VCCPRIM_VNNAON), U502.BF24 (VCCPRIM_VNNAON), U502.BF27 (VCCPRIM_VNNAON), U502.BG23 (VCCPRIM_VNNAON), U502.BG26 (VCCPRIM_VNNAON), U502.BH21 (VCCPRIM_VNNAON), U502.BH24 (VCCPRIM_VNNAON), U502.BJ23 (VCCPRIM_VNNAON), U502.BJ26 (VCCPRIM_VNNAON), U502.BK24 (VCCPRIM_VNNAON), U502.BL23 (VCCPRIM_VNNAON), U502.BL26 (VCCPRIM_VNNAON), U502.BM24 (VCCPRIM_VNNAON), U502.BN23 (VCCPRIM_VNNAON), U502.BP21 (VCCPRIM_VNNAON), U502.BP24 (VCCPRIM_VNNAON), U502.BR20 (VCCPRIM_VNNAON), U502.BR23 (VCCPRIM_VNNAON), U502.BT21 (VCCPRIM_VNNAON), U502.BT24 (VCCPRIM_VNNAON), U502.BU20 (VCCPRIM_VNNAON), U502.BV21 (VCCPRIM_VNNAON), U502.BV24 (VCCPRIM_VNNAON); also elsewhere on the board
/CPU_VCCPRIM_VNNAONLV: U502.BK27 (VCCPRIM_VNNAONLV), U502.BK30 (VCCPRIM_VNNAONLV), U502.BL28 (VCCPRIM_VNNAONLV), U502.BM27 (VCCPRIM_VNNAONLV), U502.BM30 (VCCPRIM_VNNAONLV), U502.BN28 (VCCPRIM_VNNAONLV), U502.BP27 (VCCPRIM_VNNAONLV), U502.BP30 (VCCPRIM_VNNAONLV), U502.BR26 (VCCPRIM_VNNAONLV), U502.BR28 (VCCPRIM_VNNAONLV), U502.BT27 (VCCPRIM_VNNAONLV), U502.BT30 (VCCPRIM_VNNAONLV), U502.BU26 (VCCPRIM_VNNAONLV), U502.BV27 (VCCPRIM_VNNAONLV), U502.BV30 (VCCPRIM_VNNAONLV); also elsewhere on the board
/CPU_VCCPRIM_VNNAON_FLTR: U502.BE20 (VCCPRIM_VNNAON_FLTR), U502.BG20 (VCCPRIM_VNNAON_FLTR); also elsewhere on the board
/CPU_VCCSA: U502.AU34 (VCCSA), U502.AU40 (VCCSA), U502.AU46 (VCCSA), U502.AU51 (VCCSA), U502.AV33 (VCCSA), U502.AV36 (VCCSA), U502.AV38 (VCCSA), U502.AV41 (VCCSA), U502.AV44 (VCCSA), U502.AV47 (VCCSA), U502.AV50 (VCCSA), U502.AV53 (VCCSA), U502.AV56 (VCCSA), U502.AW34 (VCCSA), U502.AW37 (VCCSA), U502.AW40 (VCCSA), U502.AW43 (VCCSA), U502.AW46 (VCCSA), U502.AW49 (VCCSA), U502.AW51 (VCCSA), U502.AW54 (VCCSA), U502.AY33 (VCCSA), U502.AY36 (VCCSA), U502.AY38 (VCCSA), U502.AY41 (VCCSA), U502.AY44 (VCCSA), U502.AY47 (VCCSA), U502.AY50 (VCCSA), U502.AY53 (VCCSA), U502.AY56 (VCCSA), U502.BA31 (VCCSA), U502.BA37 (VCCSA), U502.BA43 (VCCSA), U502.BA49 (VCCSA), U502.BA54 (VCCSA), U502.BB33 (VCCSA), U502.BB36 (VCCSA), U502.BB38 (VCCSA), U502.BB41 (VCCSA), U502.BB44 (VCCSA), U502.BB47 (VCCSA), U502.BB50 (VCCSA), U502.BB53 (VCCSA), U502.BB56 (VCCSA), U502.BC31 (VCCSA), U502.BC34 (VCCSA), U502.BC40 (VCCSA), U502.BC43 (VCCSA), U502.BC46 (VCCSA), U502.BC49 (VCCSA), U502.BC51 (VCCSA), U502.BC54 (VCCSA), U502.BD33 (VCCSA), U502.BD36 (VCCSA), U502.BD38 (VCCSA), U502.BD41 (VCCSA), U502.BD44 (VCCSA), U502.BD47 (VCCSA), U502.BD50 (VCCSA), U502.BD53 (VCCSA), U502.BD56 (VCCSA), U502.BE31 (VCCSA), U502.BE34 (VCCSA), U502.BE37 (VCCSA), U502.BE40 (VCCSA), U502.BE46 (VCCSA), U502.BE51 (VCCSA), U502.BF33 (VCCSA), U502.BF36 (VCCSA), U502.BF38 (VCCSA), U502.BF41 (VCCSA), U502.BF44 (VCCSA), U502.BF47 (VCCSA), U502.BF50 (VCCSA), U502.BF53 (VCCSA), U502.BF56 (VCCSA), U502.BG31 (VCCSA), U502.BG34 (VCCSA), U502.BG37 (VCCSA), U502.BG40 (VCCSA), U502.BG43 (VCCSA), U502.BG46 (VCCSA), U502.BG49 (VCCSA), U502.BG51 (VCCSA), U502.BG54 (VCCSA), U502.BH33 (VCCSA), U502.BH36 (VCCSA), U502.BH38 (VCCSA), U502.BH41 (VCCSA), U502.BH44 (VCCSA), U502.BH47 (VCCSA), U502.BH50 (VCCSA), U502.BH53 (VCCSA), U502.BH56 (VCCSA), U502.BJ31 (VCCSA), U502.BJ37 (VCCSA), U502.BJ54 (VCCSA), U502.BK33 (VCCSA), U502.BK36 (VCCSA), U502.BK50 (VCCSA), U502.BK53 (VCCSA), U502.BK56 (VCCSA), U502.BL31 (VCCSA), U502.BL34 (VCCSA), U502.BL37 (VCCSA), U502.BL49 (VCCSA), U502.BL51 (VCCSA), U502.BL54 (VCCSA), U502.BM33 (VCCSA), U502.BM36 (VCCSA), U502.BM50 (VCCSA), U502.BM53 (VCCSA), U502.BM56 (VCCSA), U502.BN37 (VCCSA), U502.BN51 (VCCSA), U502.BP33 (VCCSA), U502.BP36 (VCCSA), U502.BP50 (VCCSA), U502.BP53 (VCCSA), U502.BP56 (VCCSA), U502.BR31 (VCCSA), U502.BR34 (VCCSA), U502.BR37 (VCCSA), U502.BR49 (VCCSA), U502.BR51 (VCCSA), U502.BR54 (VCCSA), U502.BT33 (VCCSA), U502.BT36 (VCCSA), U502.BT50 (VCCSA), U502.BT53 (VCCSA), U502.BT56 (VCCSA), U502.BU31 (VCCSA), U502.BU37 (VCCSA), U502.BU49 (VCCSA), U502.BU54 (VCCSA), U502.BV33 (VCCSA), U502.BV36 (VCCSA), U502.BV50 (VCCSA), U502.BV53 (VCCSA), U502.BV56 (VCCSA); also elsewhere on the board
/CPU_VCCST: U502.AU31 (VCCST), U502.AV30 (VCCST); also elsewhere on the board
/CPU_VCC_ECORE: U502.BJ40 (VCC_ECORE), U502.BJ43 (VCC_ECORE), U502.BJ46 (VCC_ECORE), U502.BK38 (VCC_ECORE), U502.BK41 (VCC_ECORE), U502.BK44 (VCC_ECORE), U502.BK47 (VCC_ECORE), U502.BL43 (VCC_ECORE), U502.BM38 (VCC_ECORE), U502.BM41 (VCC_ECORE), U502.BM44 (VCC_ECORE), U502.BM47 (VCC_ECORE), U502.BN40 (VCC_ECORE), U502.BN43 (VCC_ECORE), U502.BN46 (VCC_ECORE), U502.BP38 (VCC_ECORE), U502.BP41 (VCC_ECORE), U502.BP44 (VCC_ECORE), U502.BP47 (VCC_ECORE), U502.BR43 (VCC_ECORE), U502.BT38 (VCC_ECORE), U502.BT41 (VCC_ECORE), U502.BT44 (VCC_ECORE), U502.BT47 (VCC_ECORE), U502.BU40 (VCC_ECORE), U502.BU43 (VCC_ECORE), U502.BU46 (VCC_ECORE), U502.BV38 (VCC_ECORE); also elsewhere on the board
/CPU_VDD2H: U502.BJ83 (VDD2H), U502.BJ89 (VDD2H), U502.BK82 (VDD2H), U502.BK85 (VDD2H), U502.BK88 (VDD2H), U502.BK90 (VDD2H), U502.BK93 (VDD2H), U502.BL83 (VDD2H), U502.BL86 (VDD2H), U502.BL89 (VDD2H), U502.BL92 (VDD2H), U502.BM82 (VDD2H), U502.BM85 (VDD2H), U502.BM88 (VDD2H), U502.BM90 (VDD2H), U502.BM93 (VDD2H), U502.BN86 (VDD2H), U502.BP82 (VDD2H), U502.BP85 (VDD2H), U502.BP88 (VDD2H), U502.BP90 (VDD2H), U502.BP93 (VDD2H), U502.BR83 (VDD2H), U502.BR86 (VDD2H), U502.BR89 (VDD2H), U502.BR92 (VDD2H), U502.BT82 (VDD2H), U502.BT85 (VDD2H), U502.BT88 (VDD2H), U502.BT90 (VDD2H), U502.BT93 (VDD2H); also elsewhere on the board
/CPU_VDD2H_EDGECAP_0: U502.B81 (VDD2H_EDGECAP_0), U502.B83 (VDD2H_EDGECAP_0), U502.B86 (VDD2H_EDGECAP_0); also elsewhere on the board
/CPU_VDD2L: U502.BU72 (VDD2L), U502.BU77 (VDD2L), U502.BU83 (VDD2L), U502.BU89 (VDD2L), U502.BU92 (VDD2L); also elsewhere on the board
/CPU_VDD2L_EDGECAP_0: U502.B73 (VDD2L_EDGECAP_0); also elsewhere on the board
/CPU_VDD2L_SENSE: U502.B67 (VDD2L_SENSE)
/CPU_VDDQ: U502.AT88 (VDDQ), U502.AT90 (VDDQ), U502.AT93 (VDDQ), U502.AU86 (VDDQ), U502.AV82 (VDDQ), U502.AV85 (VDDQ), U502.AV88 (VDDQ), U502.AV90 (VDDQ), U502.AV93 (VDDQ), U502.AW83 (VDDQ), U502.AW86 (VDDQ), U502.AW89 (VDDQ), U502.AW92 (VDDQ), U502.AY82 (VDDQ), U502.AY85 (VDDQ), U502.AY88 (VDDQ), U502.AY90 (VDDQ), U502.AY93 (VDDQ), U502.BA83 (VDDQ), U502.BA89 (VDDQ), U502.BB82 (VDDQ), U502.BB85 (VDDQ), U502.BB88 (VDDQ), U502.BB90 (VDDQ), U502.BB93 (VDDQ), U502.BC83 (VDDQ), U502.BC86 (VDDQ), U502.BC89 (VDDQ), U502.BC92 (VDDQ); also elsewhere on the board
/CPU_VDDQ_EDGECAP_0: U502.B75 (VDDQ_EDGECAP_0), U502.B77 (VDDQ_EDGECAP_0), U502.B79 (VDDQ_EDGECAP_0); also elsewhere on the board
/CPU_VDDQ_SENSE: U502.B65 (VDDQ_SENSE)
/CPU_VDDRIO: U502.AU57 (VDDRIO), U502.AU63 (VDDRIO), U502.AV59 (VDDRIO), U502.AV62 (VDDRIO), U502.AV64 (VDDRIO), U502.AW57 (VDDRIO), U502.AW60 (VDDRIO), U502.AW63 (VDDRIO), U502.AW66 (VDDRIO), U502.AY59 (VDDRIO), U502.AY62 (VDDRIO), U502.AY64 (VDDRIO), U502.BA60 (VDDRIO), U502.BA66 (VDDRIO), U502.BB59 (VDDRIO), U502.BB62 (VDDRIO), U502.BB64 (VDDRIO), U502.BC57 (VDDRIO), U502.BC60 (VDDRIO), U502.BC63 (VDDRIO), U502.BC66 (VDDRIO), U502.BD59 (VDDRIO), U502.BD62 (VDDRIO), U502.BD64 (VDDRIO), U502.BE57 (VDDRIO), U502.BE63 (VDDRIO), U502.BF59 (VDDRIO), U502.BF62 (VDDRIO), U502.BF64 (VDDRIO), U502.BG57 (VDDRIO), U502.BG60 (VDDRIO), U502.BG63 (VDDRIO), U502.BG66 (VDDRIO), U502.BH59 (VDDRIO), U502.BH62 (VDDRIO), U502.BH64 (VDDRIO), U502.BJ60 (VDDRIO), U502.BJ66 (VDDRIO), U502.BK59 (VDDRIO), U502.BK62 (VDDRIO), U502.BK64 (VDDRIO), U502.BL57 (VDDRIO), U502.BL60 (VDDRIO), U502.BL63 (VDDRIO), U502.BM59 (VDDRIO), U502.BM62 (VDDRIO), U502.BM64 (VDDRIO), U502.BN57 (VDDRIO), U502.BN63 (VDDRIO), U502.BP59 (VDDRIO), U502.BP62 (VDDRIO), U502.BP64 (VDDRIO), U502.BR57 (VDDRIO), U502.BR60 (VDDRIO), U502.BR63 (VDDRIO), U502.BT59 (VDDRIO), U502.BT62 (VDDRIO), U502.BT64 (VDDRIO), U502.BU60 (VDDRIO), U502.BU66 (VDDRIO), U502.BV59 (VDDRIO); also elsewhere on the board
/CPU_VDDRIO_SENSE: U502.B63 (VDDRIO_SENSE)
/GND: U502.AU6 (VSS), U502.AU11 (VSS), U502.AU13 (VSS), U502.AU28 (VSS), U502.AU37 (VSS), U502.AU43 (VSS), U502.AU49 (VSS), U502.AU54 (VSS), U502.AU60 (VSS), U502.AU66 (VSS), U502.AU72 (VSS), U502.AU77 (VSS), U502.AU83 (VSS), U502.AU89 (VSS), U502.AU92 (VSS), U502.AV7 (VSS), U502.AV9 (VSS), U502.AV12 (VSS), U502.AV15 (VSS), U502.AV18 (VSS), U502.AV21 (VSS), U502.AV24 (VSS), U502.AV27 (VSS), U502.AW6 (VSS), U502.AW11 (VSS), U502.AW13 (VSS), U502.AW28 (VSS), U502.AW31 (VSS), U502.AY7 (VSS), U502.AY12 (VSS), U502.AY15 (VSS), U502.AY18 (VSS), U502.AY30 (VSS), U502.B2 (VSS), U502.B4 (VSS), U502.B6 (VSS), U502.B8 (VSS), U502.B11 (VSS), U502.B13 (VSS), U502.B57 (VSS), U502.B59 (VSS), U502.B61 (VSS), U502.B90 (VSS), U502.BA23 (VSS), U502.BA28 (VSS), U502.BA34 (VSS), U502.BA40 (VSS), U502.BA46 (VSS), U502.BA51 (VSS), U502.BA57 (VSS), U502.BA63 (VSS), U502.BA69 (VSS), U502.BA75 (VSS), U502.BA80 (VSS), U502.BA86 (VSS), U502.BA92 (VSS), U502.BB6 (VSS), U502.BB11 (VSS), U502.BB13 (VSS), U502.BB15 (VSS), U502.BB30 (VSS), U502.BC7 (VSS), U502.BC12 (VSS), U502.BC28 (VSS), U502.BC37 (VSS), U502.BD1 (VSS), U502.BD3 (VSS), U502.BD6 (VSS), U502.BD8 (VSS), U502.BD11 (VSS), U502.BD13 (VSS), U502.BD15 (VSS), U502.BD30 (VSS), U502.BE4 (VSS), U502.BE7 (VSS), U502.BE9 (VSS), U502.BE26 (VSS), U502.BE28 (VSS), U502.BE43 (VSS), U502.BE49 (VSS), U502.BE54 (VSS), U502.BE60 (VSS), U502.BE66 (VSS), U502.BE77 (VSS), U502.BE83 (VSS), U502.BE89 (VSS), U502.BE92 (VSS), U502.BF15 (VSS), U502.BF21 (VSS), U502.BF30 (VSS), U502.BG11 (VSS), U502.BG28 (VSS), U502.BH4 (VSS), U502.BH12 (VSS), U502.BH15 (VSS), U502.BH27 (VSS), U502.BH30 (VSS), U502.BJ13 (VSS), U502.BJ28 (VSS), U502.BJ34 (VSS), U502.BJ49 (VSS), U502.BJ51 (VSS), U502.BJ57 (VSS), U502.BJ63 (VSS), U502.BJ69 (VSS), U502.BJ80 (VSS), U502.BJ86 (VSS), U502.BJ92 (VSS), U502.BK2 (VSS), U502.BK4 (VSS), U502.BK15 (VSS), U502.BK21 (VSS), U502.BL40 (VSS), U502.BL46 (VSS), U502.BL75 (VSS), U502.BM1 (VSS), U502.BM6 (VSS), U502.BM8 (VSS), U502.BM11 (VSS), U502.BM13 (VSS), U502.BM15 (VSS), U502.BM21 (VSS), U502.BN4 (VSS), U502.BN7 (VSS), U502.BN9 (VSS), U502.BN12 (VSS), U502.BN26 (VSS), U502.BN31 (VSS), U502.BN34 (VSS), U502.BN49 (VSS), U502.BN54 (VSS), U502.BN60 (VSS), U502.BN66 (VSS), U502.BN72 (VSS), U502.BN77 (VSS), U502.BN83 (VSS), U502.BN89 (VSS), U502.BN92 (VSS), U502.BP1 (VSS), U502.BP6 (VSS), U502.BP11 (VSS), U502.BP15 (VSS), U502.BR4 (VSS), U502.BR9 (VSS), U502.BR40 (VSS), U502.BR46 (VSS), U502.BT15 (VSS), U502.BU1 (VSS), U502.BU6 (VSS), U502.BU11 (VSS), U502.BU13 (VSS), U502.BU23 (VSS), U502.BU28 (VSS), U502.BU34 (VSS), U502.BU51 (VSS), U502.BU57 (VSS), U502.BU63 (VSS), U502.BU69 (VSS)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; also elsewhere on the board

Schematic: Connectivity_33.kicad_sch, Main_10E1S / Connectivity 33

Parts:
U502: Intel Core Ultra 7 268V / BGA2833; Intel_Core_Ultra_200V_BGA2833_27p5x27_ExactXY_DraftLands

Connections:
/CPU_G5_RX1_P: U502.CY17 (PCIE_6_RX_P); also elsewhere on the board
/CPU_G5_RX2_N: U502.CY22 (PCIE_7_RX_N); also elsewhere on the board
/CPU_SVID_DATA_1V25: U502.C56 (VIDSOUT); also elsewhere on the board
/CPU_V1P8U_MEM: U502.BV67 (V1P8U_MEM), U502.BV70 (V1P8U_MEM), U502.BW69 (V1P8U_MEM), U502.BY67 (V1P8U_MEM), U502.BY70 (V1P8U_MEM), U502.CA69 (V1P8U_MEM), U502.CB67 (V1P8U_MEM), U502.CB70 (V1P8U_MEM); also elsewhere on the board
/CPU_V1P8U_MEM_EDGECAP_2: U502.CE92 (V1P8U_MEM_EDGECAP_2), U502.CG92 (V1P8U_MEM_EDGECAP_2); also elsewhere on the board
/CPU_VCCL2: U502.BW40 (VCCL2), U502.BW43 (VCCL2), U502.BW46 (VCCL2); also elsewhere on the board
/CPU_VCCPRIM_1P8_FLTRB_CAP: U502.CN31 (VCCPRIM_1P8_FLTRB_CAP), U502.CN34 (VCCPRIM_1P8_FLTRB_CAP), U502.CP30 (VCCPRIM_1P8_FLTRB_CAP), U502.CP33 (VCCPRIM_1P8_FLTRB_CAP); also elsewhere on the board
/CPU_VCCPRIM_IO: U502.BW17 (VCCPRIM_IO), U502.BY18 (VCCPRIM_IO), U502.CA17 (VCCPRIM_IO), U502.CB18 (VCCPRIM_IO), U502.CC17 (VCCPRIM_IO), U502.CD18 (VCCPRIM_IO), U502.CE17 (VCCPRIM_IO), U502.CF18 (VCCPRIM_IO), U502.CG17 (VCCPRIM_IO), U502.CH18 (VCCPRIM_IO), U502.CJ17 (VCCPRIM_IO), U502.CK18 (VCCPRIM_IO), U502.CL17 (VCCPRIM_IO), U502.CM18 (VCCPRIM_IO), U502.CN17 (VCCPRIM_IO), U502.CN20 (VCCPRIM_IO), U502.CN23 (VCCPRIM_IO), U502.CN26 (VCCPRIM_IO), U502.CN28 (VCCPRIM_IO), U502.CP18 (VCCPRIM_IO), U502.CP21 (VCCPRIM_IO), U502.CP24 (VCCPRIM_IO), U502.CP27 (VCCPRIM_IO); also elsewhere on the board
/CPU_VCCPRIM_IO_SENSE: U502.CN12 (VCCPRIM_IO_SENSE)
/CPU_VCCPRIM_IO_VSS_SENSE: U502.CL13 (VCCPRIM_IO_VSS_SENSE)
/CPU_VCCPRIM_VNNAON: U502.BW20 (VCCPRIM_VNNAON), U502.BW23 (VCCPRIM_VNNAON), U502.BY21 (VCCPRIM_VNNAON), U502.BY24 (VCCPRIM_VNNAON), U502.CA23 (VCCPRIM_VNNAON), U502.CB21 (VCCPRIM_VNNAON), U502.CB24 (VCCPRIM_VNNAON), U502.CC20 (VCCPRIM_VNNAON), U502.CC23 (VCCPRIM_VNNAON), U502.CD21 (VCCPRIM_VNNAON), U502.CD24 (VCCPRIM_VNNAON), U502.CE20 (VCCPRIM_VNNAON), U502.CF21 (VCCPRIM_VNNAON), U502.CG20 (VCCPRIM_VNNAON), U502.CG23 (VCCPRIM_VNNAON), U502.CH21 (VCCPRIM_VNNAON), U502.CJ23 (VCCPRIM_VNNAON), U502.CK21 (VCCPRIM_VNNAON), U502.CK24 (VCCPRIM_VNNAON), U502.CK27 (VCCPRIM_VNNAON), U502.CK30 (VCCPRIM_VNNAON), U502.CL20 (VCCPRIM_VNNAON), U502.CL23 (VCCPRIM_VNNAON), U502.CL26 (VCCPRIM_VNNAON), U502.CL28 (VCCPRIM_VNNAON); also elsewhere on the board
/CPU_VCCPRIM_VNNAONLV: U502.BW26 (VCCPRIM_VNNAONLV), U502.BW28 (VCCPRIM_VNNAONLV), U502.BY27 (VCCPRIM_VNNAONLV), U502.BY30 (VCCPRIM_VNNAONLV), U502.CA28 (VCCPRIM_VNNAONLV), U502.CB27 (VCCPRIM_VNNAONLV), U502.CB30 (VCCPRIM_VNNAONLV), U502.CC26 (VCCPRIM_VNNAONLV), U502.CC28 (VCCPRIM_VNNAONLV), U502.CD27 (VCCPRIM_VNNAONLV), U502.CD30 (VCCPRIM_VNNAONLV), U502.CE26 (VCCPRIM_VNNAONLV), U502.CF24 (VCCPRIM_VNNAONLV), U502.CF27 (VCCPRIM_VNNAONLV), U502.CF30 (VCCPRIM_VNNAONLV), U502.CG26 (VCCPRIM_VNNAONLV), U502.CG28 (VCCPRIM_VNNAONLV), U502.CH24 (VCCPRIM_VNNAONLV), U502.CH27 (VCCPRIM_VNNAONLV), U502.CH30 (VCCPRIM_VNNAONLV), U502.CJ28 (VCCPRIM_VNNAONLV); also elsewhere on the board
/CPU_VCCPRIM_VNNAONLV_SENSE: U502.CV27 (VCCPRIM_VNNAONLV_SENSE)
/CPU_VCCPRIM_VNNAONLV_VSS_SENSE: U502.CT28 (VCCPRIM_VNNAONLV_VSS_SENSE)
/CPU_VCCPRIM_VNNAON_SENSE: U502.BY12 (VCCPRIM_VNNAON_SENSE)
/CPU_VCCPRIM_VNNAON_VSS_SENSE: U502.BW13 (VCCPRIM_VNNAON_VSS_SENSE)
/CPU_VCCSA: U502.BW31 (VCCSA), U502.BW34 (VCCSA), U502.BW37 (VCCSA), U502.BW49 (VCCSA), U502.BW51 (VCCSA), U502.BW54 (VCCSA), U502.BY33 (VCCSA), U502.CA34 (VCCSA), U502.CB33 (VCCSA), U502.CC31 (VCCSA), U502.CC34 (VCCSA), U502.CD33 (VCCSA), U502.CE31 (VCCSA), U502.CE34 (VCCSA), U502.CF33 (VCCSA), U502.CG31 (VCCSA), U502.CG34 (VCCSA), U502.CH33 (VCCSA), U502.CJ34 (VCCSA), U502.CK33 (VCCSA), U502.CL31 (VCCSA), U502.CL34 (VCCSA); also elsewhere on the board
/CPU_VCC_ECORE_SENSE: U502.CY27 (VCC_ECORE_SENSE)
/CPU_VCC_ECORE_VSS_SENSE: U502.CW28 (VCC_ECORE_VSS_SENSE)
/CPU_VCC_PCORE: U502.CA40 (VCC_PCORE), U502.CA46 (VCC_PCORE), U502.CA51 (VCC_PCORE), U502.CA57 (VCC_PCORE), U502.CA63 (VCC_PCORE), U502.CB36 (VCC_PCORE), U502.CB38 (VCC_PCORE), U502.CB41 (VCC_PCORE), U502.CB44 (VCC_PCORE), U502.CB47 (VCC_PCORE), U502.CB50 (VCC_PCORE), U502.CB53 (VCC_PCORE), U502.CB56 (VCC_PCORE), U502.CB59 (VCC_PCORE), U502.CB62 (VCC_PCORE), U502.CB64 (VCC_PCORE), U502.CC37 (VCC_PCORE), U502.CC40 (VCC_PCORE), U502.CC43 (VCC_PCORE), U502.CC46 (VCC_PCORE), U502.CC49 (VCC_PCORE), U502.CC51 (VCC_PCORE), U502.CC54 (VCC_PCORE), U502.CC57 (VCC_PCORE), U502.CC60 (VCC_PCORE), U502.CC63 (VCC_PCORE), U502.CC66 (VCC_PCORE), U502.CC69 (VCC_PCORE), U502.CC72 (VCC_PCORE), U502.CC80 (VCC_PCORE), U502.CC83 (VCC_PCORE), U502.CC86 (VCC_PCORE), U502.CD36 (VCC_PCORE), U502.CD38 (VCC_PCORE), U502.CD41 (VCC_PCORE), U502.CD44 (VCC_PCORE), U502.CD47 (VCC_PCORE), U502.CD50 (VCC_PCORE), U502.CD53 (VCC_PCORE), U502.CD56 (VCC_PCORE), U502.CD59 (VCC_PCORE), U502.CD62 (VCC_PCORE), U502.CD64 (VCC_PCORE), U502.CD67 (VCC_PCORE), U502.CD70 (VCC_PCORE), U502.CD82 (VCC_PCORE), U502.CD85 (VCC_PCORE), U502.CD88 (VCC_PCORE), U502.CE37 (VCC_PCORE), U502.CE43 (VCC_PCORE), U502.CE49 (VCC_PCORE), U502.CE54 (VCC_PCORE), U502.CE60 (VCC_PCORE), U502.CE66 (VCC_PCORE), U502.CE72 (VCC_PCORE), U502.CE83 (VCC_PCORE), U502.CE89 (VCC_PCORE), U502.CF36 (VCC_PCORE), U502.CF38 (VCC_PCORE), U502.CF41 (VCC_PCORE), U502.CF44 (VCC_PCORE), U502.CF47 (VCC_PCORE), U502.CF50 (VCC_PCORE), U502.CF53 (VCC_PCORE), U502.CF56 (VCC_PCORE), U502.CF59 (VCC_PCORE), U502.CF62 (VCC_PCORE), U502.CF64 (VCC_PCORE), U502.CF67 (VCC_PCORE), U502.CF70 (VCC_PCORE), U502.CF73 (VCC_PCORE), U502.CF76 (VCC_PCORE), U502.CF79 (VCC_PCORE), U502.CF82 (VCC_PCORE), U502.CF85 (VCC_PCORE), U502.CF88 (VCC_PCORE), U502.CG37 (VCC_PCORE), U502.CG40 (VCC_PCORE), U502.CG43 (VCC_PCORE), U502.CG46 (VCC_PCORE), U502.CG49 (VCC_PCORE), U502.CG51 (VCC_PCORE), U502.CG54 (VCC_PCORE), U502.CG57 (VCC_PCORE), U502.CG60 (VCC_PCORE), U502.CG63 (VCC_PCORE), U502.CG66 (VCC_PCORE), U502.CG69 (VCC_PCORE), U502.CG72 (VCC_PCORE), U502.CG77 (VCC_PCORE), U502.CG80 (VCC_PCORE), U502.CG83 (VCC_PCORE), U502.CG86 (VCC_PCORE), U502.CG89 (VCC_PCORE), U502.CH36 (VCC_PCORE), U502.CH38 (VCC_PCORE), U502.CH41 (VCC_PCORE), U502.CH44 (VCC_PCORE), U502.CH47 (VCC_PCORE), U502.CH50 (VCC_PCORE), U502.CH53 (VCC_PCORE), U502.CH56 (VCC_PCORE), U502.CH59 (VCC_PCORE), U502.CH62 (VCC_PCORE), U502.CH64 (VCC_PCORE), U502.CH67 (VCC_PCORE), U502.CH70 (VCC_PCORE), U502.CH73 (VCC_PCORE), U502.CH76 (VCC_PCORE), U502.CH79 (VCC_PCORE), U502.CH82 (VCC_PCORE), U502.CH85 (VCC_PCORE), U502.CH88 (VCC_PCORE), U502.CH90 (VCC_PCORE), U502.CH93 (VCC_PCORE), U502.CJ40 (VCC_PCORE), U502.CJ46 (VCC_PCORE), U502.CJ51 (VCC_PCORE), U502.CJ57 (VCC_PCORE), U502.CJ63 (VCC_PCORE), U502.CJ69 (VCC_PCORE), U502.CJ75 (VCC_PCORE), U502.CJ80 (VCC_PCORE), U502.CJ86 (VCC_PCORE), U502.CJ92 (VCC_PCORE), U502.CK36 (VCC_PCORE), U502.CK38 (VCC_PCORE), U502.CK41 (VCC_PCORE), U502.CK44 (VCC_PCORE), U502.CK47 (VCC_PCORE), U502.CK50 (VCC_PCORE), U502.CK53 (VCC_PCORE), U502.CK56 (VCC_PCORE), U502.CK59 (VCC_PCORE), U502.CK62 (VCC_PCORE), U502.CK64 (VCC_PCORE), U502.CK67 (VCC_PCORE), U502.CK70 (VCC_PCORE), U502.CK73 (VCC_PCORE), U502.CK76 (VCC_PCORE), U502.CK79 (VCC_PCORE), U502.CK82 (VCC_PCORE), U502.CK85 (VCC_PCORE), U502.CK88 (VCC_PCORE), U502.CK90 (VCC_PCORE), U502.CK93 (VCC_PCORE), U502.CL37 (VCC_PCORE), U502.CL40 (VCC_PCORE), U502.CL43 (VCC_PCORE), U502.CL46 (VCC_PCORE), U502.CL49 (VCC_PCORE), U502.CL51 (VCC_PCORE), U502.CL54 (VCC_PCORE), U502.CL57 (VCC_PCORE), U502.CL60 (VCC_PCORE), U502.CL63 (VCC_PCORE), U502.CL66 (VCC_PCORE), U502.CL69 (VCC_PCORE)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; also elsewhere on the board
/CPU_VDD2L: U502.BV73 (VDD2L), U502.BV76 (VDD2L), U502.BV79 (VDD2L), U502.BV82 (VDD2L), U502.BV85 (VDD2L), U502.BV88 (VDD2L), U502.BW72 (VDD2L), U502.BW75 (VDD2L), U502.BW77 (VDD2L), U502.BW80 (VDD2L), U502.BW83 (VDD2L), U502.BW86 (VDD2L), U502.BW89 (VDD2L), U502.BW92 (VDD2L), U502.BY73 (VDD2L), U502.BY76 (VDD2L), U502.BY79 (VDD2L), U502.BY82 (VDD2L), U502.BY85 (VDD2L), U502.BY88 (VDD2L), U502.CA80 (VDD2L), U502.CA86 (VDD2L), U502.CA89 (VDD2L), U502.CA92 (VDD2L), U502.CB82 (VDD2L), U502.CB85 (VDD2L), U502.CB88 (VDD2L); also elsewhere on the board
/CPU_VDD2L_VSS_SENSE: U502.C66 (VDD2L_VSS_SENSE)
/CPU_VDDQ_VSS_SENSE: U502.C64 (VDDQ_VSS_SENSE)
/CPU_VDDRIO: U502.BV62 (VDDRIO), U502.BV64 (VDDRIO), U502.BW57 (VDDRIO), U502.BW60 (VDDRIO), U502.BW63 (VDDRIO), U502.BW66 (VDDRIO), U502.BY59 (VDDRIO), U502.BY62 (VDDRIO), U502.BY64 (VDDRIO); also elsewhere on the board
/CPU_VDDRIO_VSS_SENSE: U502.C62 (VDDRIO_VSS_SENSE)
/GND: U502.BV90 (VSS), U502.BV93 (VSS), U502.BW1 (VSS), U502.BW6 (VSS), U502.BW8 (VSS), U502.BW11 (VSS), U502.BY4 (VSS), U502.BY7 (VSS), U502.BY9 (VSS), U502.BY15 (VSS), U502.BY36 (VSS), U502.BY38 (VSS), U502.BY41 (VSS), U502.BY44 (VSS), U502.BY47 (VSS), U502.BY50 (VSS), U502.BY53 (VSS), U502.BY56 (VSS), U502.BY90 (VSS), U502.BY93 (VSS), U502.C10 (VSS), U502.C12 (VSS), U502.C14 (VSS), U502.C16 (VSS), U502.C18 (VSS), U502.C20 (VSS), U502.C22 (VSS), U502.C24 (VSS), U502.C26 (VSS), U502.C28 (VSS), U502.C30 (VSS), U502.C32 (VSS), U502.C34 (VSS), U502.C36 (VSS), U502.C38 (VSS), U502.C40 (VSS), U502.C42 (VSS), U502.C44 (VSS), U502.C46 (VSS), U502.C48 (VSS), U502.C50 (VSS), U502.C52 (VSS), U502.C54 (VSS), U502.C68 (VSS), U502.C70 (VSS), U502.C72 (VSS), U502.C74 (VSS), U502.C76 (VSS), U502.C78 (VSS), U502.C80 (VSS), U502.C82 (VSS), U502.C84 (VSS), U502.CA20 (VSS), U502.CA26 (VSS), U502.CA31 (VSS), U502.CA37 (VSS), U502.CA43 (VSS), U502.CA49 (VSS), U502.CA54 (VSS), U502.CA60 (VSS), U502.CA66 (VSS), U502.CA72 (VSS), U502.CA83 (VSS), U502.CB1 (VSS), U502.CB6 (VSS), U502.CB11 (VSS), U502.CB13 (VSS), U502.CB15 (VSS), U502.CB93 (VSS), U502.CC4 (VSS), U502.CC9 (VSS), U502.CC12 (VSS), U502.CC89 (VSS), U502.CD1 (VSS), U502.CD6 (VSS), U502.CD11 (VSS), U502.CD15 (VSS), U502.CD93 (VSS), U502.CE4 (VSS), U502.CE9 (VSS), U502.CE23 (VSS), U502.CE28 (VSS), U502.CE40 (VSS), U502.CE46 (VSS), U502.CE51 (VSS), U502.CE57 (VSS), U502.CE63 (VSS), U502.CE69 (VSS), U502.CE80 (VSS), U502.CE86 (VSS), U502.CF1 (VSS), U502.CF6 (VSS), U502.CF8 (VSS), U502.CF11 (VSS), U502.CF13 (VSS), U502.CF15 (VSS), U502.CF90 (VSS), U502.CF93 (VSS), U502.CG75 (VSS), U502.CH4 (VSS), U502.CH7 (VSS), U502.CH9 (VSS), U502.CH12 (VSS), U502.CH15 (VSS), U502.CJ1 (VSS), U502.CJ6 (VSS), U502.CJ11 (VSS), U502.CJ13 (VSS), U502.CJ20 (VSS), U502.CJ26 (VSS), U502.CJ31 (VSS), U502.CJ37 (VSS), U502.CJ43 (VSS), U502.CJ49 (VSS), U502.CJ54 (VSS), U502.CJ60 (VSS), U502.CJ66 (VSS), U502.CJ72 (VSS), U502.CJ77 (VSS), U502.CJ83 (VSS), U502.CJ89 (VSS), U502.CK4 (VSS), U502.CK9 (VSS), U502.CK12 (VSS), U502.CK15 (VSS), U502.CL1 (VSS), U502.CL6 (VSS), U502.CL11 (VSS), U502.CL92 (VSS), U502.CM15 (VSS), U502.CM21 (VSS), U502.CM24 (VSS), U502.CM27 (VSS), U502.CM30 (VSS), U502.CM33 (VSS), U502.CN4 (VSS), U502.CN9 (VSS), U502.CN40 (VSS), U502.CN46 (VSS), U502.CN51 (VSS), U502.CN57 (VSS), U502.CN63 (VSS), U502.CN69 (VSS), U502.CN75 (VSS), U502.CN80 (VSS), U502.CN86 (VSS), U502.CP1 (VSS), U502.CP3 (VSS), U502.CP6 (VSS), U502.CP8 (VSS), U502.CP11 (VSS), U502.CP13 (VSS), U502.CP15 (VSS), U502.CR7 (VSS), U502.CR9 (VSS), U502.CR12 (VSS), U502.CR14 (VSS), U502.CR17 (VSS)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; also elsewhere on the board

Schematic: Connectivity_34.kicad_sch, Main_10E1S / Connectivity 34

Parts:
U502: Intel Core Ultra 7 268V / BGA2833; Intel_Core_Ultra_200V_BGA2833_27p5x27_ExactXY_DraftLands

Connections:
/CPU_ACPRESENT: U502.P45 (GPP_V01); also elsewhere on the board
/CPU_BATLOW_N: U502.R50 (GPP_V00); also elsewhere on the board
/CPU_CLKREQ1_N: U502.F50 (GPP_C10); also elsewhere on the board
/CPU_CLKREQ2_N: U502.E51 (GPP_C11); also elsewhere on the board
/CPU_G5_RX0_N: U502.DD16 (PCIE_5_RX_N); also elsewhere on the board
/CPU_G5_RX0_P: U502.DE14 (PCIE_5_RX_P); also elsewhere on the board
/CPU_G5_RX1_N: U502.DA18 (PCIE_6_RX_N); also elsewhere on the board
/CPU_G5_RX2_P: U502.DA21 (PCIE_7_RX_P); also elsewhere on the board
/CPU_G5_RX3_N: U502.DC24 (PCIE_8_RX_N); also elsewhere on the board
/CPU_G5_RX3_P: U502.DD23 (PCIE_8_RX_P); also elsewhere on the board
/CPU_G5_TX0_N: U502.DL16 (PCIE_5_TX_N); also elsewhere on the board
/CPU_G5_TX0_P: U502.DK17 (PCIE_5_TX_P); also elsewhere on the board
/CPU_G5_TX1_N: U502.DH17 (PCIE_6_TX_N); also elsewhere on the board
/CPU_G5_TX1_P: U502.DF18 (PCIE_6_TX_P); also elsewhere on the board
/CPU_G5_TX2_N: U502.DH22 (PCIE_7_TX_N); also elsewhere on the board
/CPU_G5_TX2_P: U502.DF21 (PCIE_7_TX_P); also elsewhere on the board
/CPU_G5_TX3_N: U502.DL23 (PCIE_8_TX_N); also elsewhere on the board
/CPU_G5_TX3_P: U502.DK22 (PCIE_8_TX_P); also elsewhere on the board
/CPU_PCIE4_RCOMP: U502.DL39 (PCIE4_RCOMP); also elsewhere on the board
/CPU_PCIE5_RCOMP: U502.DA1 (PCIE5_RCOMP); also elsewhere on the board
/CPU_PERST_1V8_N: U502.F24 (GPP_B13); also elsewhere on the board
/CPU_PLT_PWROK: U502.H13 (PLT_PWROK); also elsewhere on the board
/CPU_PMCALERT_N: U502.F42 (GPP_E21); also elsewhere on the board
/CPU_PWRBTN_1V8_N: U502.P47 (GPP_V03); also elsewhere on the board
/CPU_RSMRST_N: U502.E13 (RSMRST#); also elsewhere on the board
/CPU_RTCRST_N: U502.H15 (RTCRST#); also elsewhere on the board
/CPU_SLP_S3_1V8_N: U502.M44 (GPP_V04); also elsewhere on the board
/CPU_SLP_S4_1V8_N: U502.L55 (GPP_V05); also elsewhere on the board
/CPU_SLP_S5_1V8_N: U502.P53 (GPP_V09); also elsewhere on the board
/CPU_SVID_ALERT_1V25_N: U502.F56 (VIDALERT#); also elsewhere on the board
/CPU_SVID_CLK_1V25: U502.E55 (VIDSCK); also elsewhere on the board
/CPU_SYS_PWROK_1V8: U502.H31 (SYS_PWROK); also elsewhere on the board
/CPU_SYS_RESET_1V8_N: U502.M52 (SYS_RESET#); also elsewhere on the board
/CPU_V1P8U_MEM_EDGECAP_3: U502.DK68 (V1P8U_MEM_EDGECAP_3), U502.DK70 (V1P8U_MEM_EDGECAP_3); also elsewhere on the board
/CPU_VCCGT: U502.D88 (VCCGT), U502.D90 (VCCGT), U502.D92 (VCCGT), U502.D93 (VCCGT), U502.E69 (VCCGT), U502.E71 (VCCGT), U502.E73 (VCCGT), U502.E75 (VCCGT), U502.E77 (VCCGT), U502.E79 (VCCGT), U502.E81 (VCCGT), U502.E83 (VCCGT), U502.F68 (VCCGT), U502.F70 (VCCGT), U502.F72 (VCCGT), U502.F74 (VCCGT), U502.F76 (VCCGT), U502.F78 (VCCGT), U502.F80 (VCCGT), U502.F82 (VCCGT), U502.F84 (VCCGT), U502.F86 (VCCGT), U502.F88 (VCCGT), U502.F90 (VCCGT), U502.F93 (VCCGT), U502.H67 (VCCGT), U502.H69 (VCCGT), U502.H73 (VCCGT), U502.H75 (VCCGT), U502.H77 (VCCGT), U502.H81 (VCCGT), U502.H83 (VCCGT), U502.H88 (VCCGT), U502.H90 (VCCGT), U502.H92 (VCCGT), U502.H93 (VCCGT), U502.J66 (VCCGT), U502.J68 (VCCGT), U502.J70 (VCCGT), U502.J72 (VCCGT), U502.J74 (VCCGT), U502.J76 (VCCGT), U502.J78 (VCCGT), U502.J80 (VCCGT), U502.J82 (VCCGT), U502.J84 (VCCGT), U502.K88 (VCCGT), U502.K90 (VCCGT), U502.K93 (VCCGT), U502.L65 (VCCGT), U502.L69 (VCCGT), U502.L71 (VCCGT), U502.L73 (VCCGT), U502.L77 (VCCGT), U502.L79 (VCCGT), U502.L81 (VCCGT), U502.L86 (VCCGT), U502.L89 (VCCGT), U502.L92 (VCCGT), U502.M64 (VCCGT), U502.M66 (VCCGT), U502.M68 (VCCGT), U502.M70 (VCCGT), U502.M72 (VCCGT), U502.M74 (VCCGT), U502.M76 (VCCGT), U502.M78 (VCCGT), U502.M80 (VCCGT), U502.M82 (VCCGT), U502.M84 (VCCGT), U502.M88 (VCCGT), U502.M90 (VCCGT), U502.M93 (VCCGT), U502.N86 (VCCGT), U502.P65 (VCCGT), U502.P67 (VCCGT), U502.P69 (VCCGT), U502.P73 (VCCGT), U502.P75 (VCCGT), U502.P77 (VCCGT), U502.P81 (VCCGT), U502.P83 (VCCGT), U502.P88 (VCCGT), U502.P90 (VCCGT), U502.P93 (VCCGT), U502.R64 (VCCGT), U502.R66 (VCCGT), U502.R68 (VCCGT); also elsewhere on the board
/CPU_VCCGT_SENSE: U502.F64 (VCCGT_SENSE)
/CPU_VCCGT_VSS_SENSE: U502.H63 (VCCGT_VSS_SENSE)
/CPU_VCCL2_SENSE: U502.DJ63 (VCCL2_SENSE)
/CPU_VCCL2_VSS_SENSE: U502.DG62 (VCCL2_VSS_SENSE)
/CPU_VCCSA_SENSE: U502.DG64 (VCCSA_SENSE)
/CPU_VCCSA_VSS_SENSE: U502.DJ65 (VCCSA_VSS_SENSE)
/CPU_VCCST_EN_1V8: U502.M48 (GPP_V16); also elsewhere on the board
/CPU_VCC_PCORE: U502.CY65 (VCC_PCORE), U502.CY67 (VCC_PCORE), U502.CY69 (VCC_PCORE), U502.CY71 (VCC_PCORE), U502.CY73 (VCC_PCORE), U502.CY75 (VCC_PCORE), U502.CY77 (VCC_PCORE), U502.CY79 (VCC_PCORE), U502.CY81 (VCC_PCORE), U502.CY83 (VCC_PCORE), U502.CY88 (VCC_PCORE), U502.CY90 (VCC_PCORE), U502.CY93 (VCC_PCORE), U502.DA64 (VCC_PCORE), U502.DA68 (VCC_PCORE), U502.DA70 (VCC_PCORE), U502.DA72 (VCC_PCORE), U502.DA76 (VCC_PCORE), U502.DA78 (VCC_PCORE), U502.DA80 (VCC_PCORE), U502.DA85 (VCC_PCORE), U502.DA89 (VCC_PCORE), U502.DA92 (VCC_PCORE), U502.DB88 (VCC_PCORE), U502.DB90 (VCC_PCORE), U502.DB93 (VCC_PCORE), U502.DC65 (VCC_PCORE), U502.DC67 (VCC_PCORE), U502.DC69 (VCC_PCORE), U502.DC71 (VCC_PCORE), U502.DC73 (VCC_PCORE), U502.DC75 (VCC_PCORE), U502.DC77 (VCC_PCORE), U502.DC79 (VCC_PCORE), U502.DC81 (VCC_PCORE), U502.DC83 (VCC_PCORE), U502.DC86 (VCC_PCORE), U502.DC89 (VCC_PCORE), U502.DD66 (VCC_PCORE), U502.DD68 (VCC_PCORE), U502.DD72 (VCC_PCORE), U502.DD74 (VCC_PCORE), U502.DD76 (VCC_PCORE), U502.DD80 (VCC_PCORE), U502.DD82 (VCC_PCORE), U502.DD86 (VCC_PCORE), U502.DD88 (VCC_PCORE), U502.DD90 (VCC_PCORE), U502.DD92 (VCC_PCORE), U502.DD93 (VCC_PCORE), U502.DF67 (VCC_PCORE), U502.DF69 (VCC_PCORE), U502.DF71 (VCC_PCORE), U502.DF73 (VCC_PCORE), U502.DF75 (VCC_PCORE), U502.DF77 (VCC_PCORE), U502.DF79 (VCC_PCORE), U502.DF81 (VCC_PCORE), U502.DF83 (VCC_PCORE), U502.DF84 (VCC_PCORE), U502.DF86 (VCC_PCORE), U502.DF90 (VCC_PCORE), U502.DF93 (VCC_PCORE), U502.DG68 (VCC_PCORE), U502.DG70 (VCC_PCORE), U502.DG72 (VCC_PCORE), U502.DG74 (VCC_PCORE), U502.DG76 (VCC_PCORE), U502.DG78 (VCC_PCORE), U502.DG80 (VCC_PCORE), U502.DG82 (VCC_PCORE), U502.DH86 (VCC_PCORE), U502.DH88 (VCC_PCORE), U502.DH90 (VCC_PCORE), U502.DH92 (VCC_PCORE), U502.DH93 (VCC_PCORE), U502.DK44 (VCC_PCORE), U502.DK48 (VCC_PCORE), U502.DK52 (VCC_PCORE), U502.DK56 (VCC_PCORE), U502.DK60 (VCC_PCORE), U502.DK64 (VCC_PCORE), U502.DK88 (VCC_PCORE), U502.DK90 (VCC_PCORE), U502.DK93 (VCC_PCORE), U502.DL90 (VCC_PCORE), U502.DL92 (VCC_PCORE), U502.DL93 (VCC_PCORE); also elsewhere on the board
/CPU_VCC_PCORE_SENSE: U502.DG60 (VCC_PCORE_SENSE)
/CPU_VCC_PCORE_VSS_SENSE: U502.DJ61 (VCC_PCORE_VSS_SENSE)
/CPU_VDD2H_EDGECAP_1: U502.DK80 (VDD2H_EDGECAP_1), U502.DK82 (VDD2H_EDGECAP_1), U502.DK84 (VDD2H_EDGECAP_1); also elsewhere on the board
/CPU_VDD2H_SENSE: U502.DJ67 (VDD2H_SENSE)
/CPU_VDD2H_VSS_SENSE: U502.DG66 (VDD2H_VSS_SENSE)
/CPU_VDD2L_EDGECAP_1: U502.DK72 (VDD2L_EDGECAP_1); also elsewhere on the board
/CPU_VDDQ_EDGECAP_1: U502.DK74 (VDDQ_EDGECAP_1), U502.DK76 (VDDQ_EDGECAP_1), U502.DK78 (VDDQ_EDGECAP_1); also elsewhere on the board
/CPU_WAKE_N: U502.P49 (GPP_V12); also elsewhere on the board
/CPU_XTAL_IN: U502.M1 (XTAL_IN); also elsewhere on the board
/CPU_XTAL_OUT: U502.N2 (XTAL_OUT); also elsewhere on the board
/GND: U502.CY63 (VSS), U502.D1 (VSS), U502.D2 (VSS), U502.D4 (VSS), U502.D86 (VSS), U502.DA3 (VSS), U502.DA13 (VSS), U502.DA16 (VSS), U502.DA23 (VSS), U502.DA26 (VSS), U502.DA28 (VSS), U502.DA31 (VSS), U502.DA33 (VSS), U502.DA66 (VSS), U502.DA74 (VSS), U502.DA82 (VSS), U502.DA86 (VSS), U502.DC2 (VSS), U502.DC9 (VSS), U502.DC14 (VSS), U502.DC17 (VSS), U502.DC19 (VSS), U502.DC22 (VSS), U502.DC27 (VSS), U502.DC29 (VSS), U502.DC32 (VSS), U502.DC34 (VSS), U502.DC61 (VSS), U502.DC63 (VSS), U502.DC92 (VSS), U502.DD1 (VSS), U502.DD13 (VSS), U502.DD18 (VSS), U502.DD21 (VSS), U502.DD26 (VSS), U502.DD28 (VSS), U502.DD31 (VSS), U502.DD33 (VSS), U502.DD36 (VSS), U502.DD70 (VSS), U502.DD78 (VSS), U502.DD84 (VSS), U502.DE9 (VSS), U502.DE12 (VSS), U502.DE17 (VSS), U502.DE19 (VSS), U502.DE22 (VSS), U502.DE24 (VSS), U502.DE37 (VSS), U502.DF1 (VSS), U502.DF2 (VSS), U502.DF4 (VSS), U502.DF11 (VSS), U502.DF13 (VSS), U502.DF16 (VSS), U502.DF23 (VSS), U502.DF26 (VSS), U502.DF39 (VSS), U502.DF41 (VSS), U502.DF43 (VSS), U502.DF45 (VSS), U502.DF47 (VSS), U502.DF49 (VSS), U502.DF51 (VSS), U502.DF53 (VSS), U502.DF55 (VSS), U502.DF57 (VSS), U502.DF59 (VSS), U502.DF88 (VSS), U502.DF92 (VSS), U502.DH1 (VSS), U502.DH2 (VSS), U502.DH4 (VSS), U502.DH9 (VSS), U502.DH14 (VSS), U502.DH19 (VSS), U502.DH24 (VSS), U502.DH27 (VSS), U502.DH29 (VSS), U502.DH32 (VSS), U502.DH34 (VSS), U502.DH37 (VSS), U502.DH84 (VSS), U502.DJ13 (VSS), U502.DJ16 (VSS), U502.DJ18 (VSS), U502.DJ21 (VSS), U502.DJ23 (VSS), U502.DJ36 (VSS), U502.DJ39 (VSS), U502.DJ69 (VSS), U502.DJ71 (VSS), U502.DJ73 (VSS), U502.DJ75 (VSS), U502.DJ77 (VSS), U502.DJ79 (VSS), U502.DJ81 (VSS), U502.DJ83 (VSS), U502.DK2 (VSS), U502.DK4 (VSS), U502.DK6 (VSS), U502.DK8 (VSS), U502.DK9 (VSS), U502.DK14 (VSS), U502.DK19 (VSS), U502.DK24 (VSS), U502.DK37 (VSS), U502.DK40 (VSS), U502.DK86 (VSS), U502.DK92 (VSS), U502.DL4 (VSS), U502.DL6 (VSS), U502.DL8 (VSS), U502.DL13 (VSS), U502.DL18 (VSS), U502.DL21 (VSS), U502.DL26 (VSS), U502.DL28 (VSS), U502.DL31 (VSS), U502.DL33 (VSS), U502.DL36 (VSS), U502.DL41 (VSS), U502.DL43 (VSS), U502.DL47 (VSS), U502.DL51 (VSS), U502.DL55 (VSS), U502.DL59 (VSS), U502.DL63 (VSS), U502.DL67 (VSS), U502.DL69 (VSS), U502.DL71 (VSS), U502.DL73 (VSS), U502.DL75 (VSS), U502.DL77 (VSS), U502.DL79 (VSS), U502.DL81 (VSS), U502.DL83 (VSS), U502.DL84 (VSS), U502.DL86 (VSS), U502.DL88 (VSS), U502.E61 (VSS), U502.E63 (VSS), U502.E65 (VSS), U502.E67 (VSS), U502.F1 (VSS), U502.F2 (VSS), U502.F66 (VSS), U502.F92 (VSS), U502.H6 (VSS), U502.H65 (VSS), U502.H71 (VSS), U502.H79 (VSS), U502.H86 (VSS), U502.J1 (VSS), U502.J3 (VSS), U502.J10 (VSS), U502.J12 (VSS), U502.J14 (VSS)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; also elsewhere on the board
