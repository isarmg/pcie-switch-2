# Repository isarmg/pcie-switch-2 (continued)

## KiCad design outputs/PCIe_3board_RevL/Main_10E1S/Main_10E1S.kicad_pcb (continued)

Schematic: Connectivity_15.kicad_sch, Main_10E1S / Connectivity 15

Parts:
J3, J4, J5, J6, J7, J8, J9, J10: HSEC6-028-01-S-DV-WT-TR; Samtec_HSEC6-028-01-S-DV-WT
J11: 12V 15A FEED A; WireSolder_2x_8x5_P12
J12: 12V 15A FEED B; WireSolder_2x_8x5_P12
J101: M1 TX0; Twinax_85R_Solder_DRAFT
J102: M1 RX0; Twinax_85R_Solder_DRAFT

Connections:
/GND: J3.A1, J3.A2, J3.A3, J3.A4, J3.A5, J3.A6, J3.A13, J3.A16, J3.A19, J3.A22, J3.A25, J3.A28, J3.B13, J3.B16, J3.B19, J3.B22, J3.B25, J3.B28, J4.A1, J4.A2, J4.A3, J4.A4, J4.A5, J4.A6, J4.A13, J4.A16, J4.A19, J4.A22, J4.A25, J4.A28, J4.B13, J4.B16, J4.B19, J4.B22, J4.B25, J4.B28, J5.A1, J5.A2, J5.A3, J5.A4, J5.A5, J5.A6, J5.A13, J5.A16, J5.A19, J5.A22, J5.A25, J5.A28, J5.B13, J5.B16, J5.B19, J5.B22, J5.B25, J5.B28, J6.A1, J6.A2, J6.A3, J6.A4, J6.A5, J6.A6, J6.A13, J6.A16, J6.A19, J6.A22, J6.A25, J6.A28, J6.B13, J6.B16, J6.B19, J6.B22, J6.B25, J6.B28, J7.A1, J7.A2, J7.A3, J7.A4, J7.A5, J7.A6, J7.A13, J7.A16, J7.A19, J7.A22, J7.A25, J7.A28, J7.B13, J7.B16, J7.B19, J7.B22, J7.B25, J7.B28, J8.A1, J8.A2, J8.A3, J8.A4, J8.A5, J8.A6, J8.A13, J8.A16, J8.A19, J8.A22, J8.A25, J8.A28, J8.B13, J8.B16, J8.B19, J8.B22, J8.B25, J8.B28, J9.A1, J9.A2, J9.A3, J9.A4, J9.A5, J9.A6, J9.A13, J9.A16, J9.A19, J9.A22, J9.A25, J9.A28, J9.B13, J9.B16, J9.B19, J9.B22, J9.B25, J9.B28, J10.A1, J10.A2, J10.A3, J10.A4, J10.A5, J10.A6, J10.A13, J10.A16, J10.A19, J10.A22, J10.A25, J10.A28, J10.B13, J10.B16, J10.B19, J10.B22, J10.B25, J10.B28, J11.2, J12.2, J101.G, J102.G; also elsewhere on the board
/M1_RX0_N: J102.N; also elsewhere on the board
/M1_RX0_P: J102.P; also elsewhere on the board
/M1_TX0_N: J101.N; also elsewhere on the board
/M1_TX0_P: J101.P; also elsewhere on the board
/P3V3_AUX: J3.B11, J4.B11, J5.B11, J6.B11, J7.B11, J8.B11, J9.B11, J10.B11; also elsewhere on the board
/P12_SLOT03: J3.B1, J3.B2, J3.B3, J3.B4, J3.B5, J3.B6; also elsewhere on the board
/P12_SLOT04: J4.B1, J4.B2, J4.B3, J4.B4, J4.B5, J4.B6; also elsewhere on the board
/P12_SLOT05: J5.B1, J5.B2, J5.B3, J5.B4, J5.B5, J5.B6; also elsewhere on the board
/P12_SLOT06: J6.B1, J6.B2, J6.B3, J6.B4, J6.B5, J6.B6; also elsewhere on the board
/P12_SLOT07: J7.B1, J7.B2, J7.B3, J7.B4, J7.B5, J7.B6; also elsewhere on the board
/P12_SLOT08: J8.B1, J8.B2, J8.B3, J8.B4, J8.B5, J8.B6; also elsewhere on the board
/P12_SLOT09: J9.B1, J9.B2, J9.B3, J9.B4, J9.B5, J9.B6; also elsewhere on the board
/P12_SLOT10: J10.B1, J10.B2, J10.B3, J10.B4, J10.B5, J10.B6; also elsewhere on the board
/S03_DUALPORTEN_N: J3.B9
/S03_LED: J3.A10
/S03_PERST0_N: J3.B10
/S03_PERST1_CLKREQ_N: J3.A11
/S03_PRSNT0_N: J3.A12
/S03_PWRDIS: J3.B12
/S03_REFCLK0_N: J3.B14; also elsewhere on the board
/S03_REFCLK0_P: J3.B15; also elsewhere on the board
/S03_REFCLK1_N: J3.A14
/S03_REFCLK1_P: J3.A15
/S03_SMBCLK_I3CCLK: J3.A7
/S03_SMBDATA_I3CDATA: J3.A8
/S03_SMRST_N: J3.A9
/S03_SW_RX0_N: J3.A17; also elsewhere on the board
/S03_SW_RX0_P: J3.A18; also elsewhere on the board
/S03_SW_RX1_N: J3.A20; also elsewhere on the board
/S03_SW_RX1_P: J3.A21; also elsewhere on the board
/S03_SW_RX2_N: J3.A23; also elsewhere on the board
/S03_SW_RX2_P: J3.A24; also elsewhere on the board
/S03_SW_RX3_N: J3.A26; also elsewhere on the board
/S03_SW_RX3_P: J3.A27; also elsewhere on the board
/S03_SW_TX0_N: J3.B17; also elsewhere on the board
/S03_SW_TX0_P: J3.B18; also elsewhere on the board
/S03_SW_TX1_N: J3.B20; also elsewhere on the board
/S03_SW_TX1_P: J3.B21; also elsewhere on the board
/S03_SW_TX2_N: J3.B23; also elsewhere on the board
/S03_SW_TX2_P: J3.B24; also elsewhere on the board
/S03_SW_TX3_N: J3.B26; also elsewhere on the board
/S03_SW_TX3_P: J3.B27; also elsewhere on the board
/S04_DUALPORTEN_N: J4.B9
/S04_LED: J4.A10
/S04_PERST0_N: J4.B10
/S04_PERST1_CLKREQ_N: J4.A11
/S04_PRSNT0_N: J4.A12
/S04_PWRDIS: J4.B12
/S04_REFCLK0_N: J4.B14; also elsewhere on the board
/S04_REFCLK0_P: J4.B15; also elsewhere on the board
/S04_REFCLK1_N: J4.A14
/S04_REFCLK1_P: J4.A15
/S04_SMBCLK_I3CCLK: J4.A7
/S04_SMBDATA_I3CDATA: J4.A8
/S04_SMRST_N: J4.A9
/S04_SW_RX0_N: J4.A17; also elsewhere on the board
/S04_SW_RX0_P: J4.A18; also elsewhere on the board
/S04_SW_RX1_N: J4.A20; also elsewhere on the board
/S04_SW_RX1_P: J4.A21; also elsewhere on the board
/S04_SW_RX2_N: J4.A23; also elsewhere on the board
/S04_SW_RX2_P: J4.A24; also elsewhere on the board
/S04_SW_RX3_N: J4.A26; also elsewhere on the board
/S04_SW_RX3_P: J4.A27; also elsewhere on the board
/S04_SW_TX0_N: J4.B17; also elsewhere on the board
/S04_SW_TX0_P: J4.B18; also elsewhere on the board
/S04_SW_TX1_N: J4.B20; also elsewhere on the board
/S04_SW_TX1_P: J4.B21; also elsewhere on the board
/S04_SW_TX2_N: J4.B23; also elsewhere on the board
/S04_SW_TX2_P: J4.B24; also elsewhere on the board
/S04_SW_TX3_N: J4.B26; also elsewhere on the board
/S04_SW_TX3_P: J4.B27; also elsewhere on the board
/S05_DUALPORTEN_N: J5.B9
/S05_LED: J5.A10
/S05_PERST0_N: J5.B10
/S05_PERST1_CLKREQ_N: J5.A11
/S05_PRSNT0_N: J5.A12
/S05_PWRDIS: J5.B12
/S05_REFCLK0_N: J5.B14; also elsewhere on the board
/S05_REFCLK0_P: J5.B15; also elsewhere on the board
/S05_REFCLK1_N: J5.A14
/S05_REFCLK1_P: J5.A15
/S05_SMBCLK_I3CCLK: J5.A7
/S05_SMBDATA_I3CDATA: J5.A8
/S05_SMRST_N: J5.A9
/S05_SW_RX0_N: J5.A17; also elsewhere on the board
/S05_SW_RX0_P: J5.A18; also elsewhere on the board
/S05_SW_RX1_N: J5.A20; also elsewhere on the board
/S05_SW_RX1_P: J5.A21; also elsewhere on the board
/S05_SW_RX2_N: J5.A23; also elsewhere on the board
/S05_SW_RX2_P: J5.A24; also elsewhere on the board
/S05_SW_RX3_N: J5.A26; also elsewhere on the board
/S05_SW_RX3_P: J5.A27; also elsewhere on the board
/S05_SW_TX0_N: J5.B17; also elsewhere on the board
/S05_SW_TX0_P: J5.B18; also elsewhere on the board
/S05_SW_TX1_N: J5.B20; also elsewhere on the board
/S05_SW_TX1_P: J5.B21; also elsewhere on the board
/S05_SW_TX2_N: J5.B23; also elsewhere on the board
/S05_SW_TX2_P: J5.B24; also elsewhere on the board
/S05_SW_TX3_N: J5.B26; also elsewhere on the board
/S05_SW_TX3_P: J5.B27; also elsewhere on the board
/S06_DUALPORTEN_N: J6.B9
/S06_LED: J6.A10
/S06_PERST0_N: J6.B10
/S06_PERST1_CLKREQ_N: J6.A11
/S06_PRSNT0_N: J6.A12
/S06_PWRDIS: J6.B12
/S06_REFCLK0_N: J6.B14; also elsewhere on the board
/S06_REFCLK0_P: J6.B15; also elsewhere on the board
/S06_REFCLK1_N: J6.A14
/S06_REFCLK1_P: J6.A15
/S06_SMBCLK_I3CCLK: J6.A7
/S06_SMBDATA_I3CDATA: J6.A8
/S06_SMRST_N: J6.A9
/S06_SW_RX0_N: J6.A17; also elsewhere on the board
/S06_SW_RX0_P: J6.A18; also elsewhere on the board
/S06_SW_RX1_N: J6.A20; also elsewhere on the board
/S06_SW_RX1_P: J6.A21; also elsewhere on the board
/S06_SW_RX2_N: J6.A23; also elsewhere on the board
/S06_SW_RX2_P: J6.A24; also elsewhere on the board
/S06_SW_RX3_N: J6.A26; also elsewhere on the board
/S06_SW_RX3_P: J6.A27; also elsewhere on the board
/S06_SW_TX0_N: J6.B17; also elsewhere on the board
/S06_SW_TX0_P: J6.B18; also elsewhere on the board
/S06_SW_TX1_N: J6.B20; also elsewhere on the board
/S06_SW_TX1_P: J6.B21; also elsewhere on the board
/S06_SW_TX2_N: J6.B23; also elsewhere on the board
/S06_SW_TX2_P: J6.B24; also elsewhere on the board
/S06_SW_TX3_N: J6.B26; also elsewhere on the board
/S06_SW_TX3_P: J6.B27; also elsewhere on the board
/S07_DUALPORTEN_N: J7.B9
/S07_LED: J7.A10
/S07_PERST0_N: J7.B10
/S07_PERST1_CLKREQ_N: J7.A11
/S07_PRSNT0_N: J7.A12
/S07_PWRDIS: J7.B12
/S07_REFCLK0_N: J7.B14; also elsewhere on the board
/S07_REFCLK0_P: J7.B15; also elsewhere on the board
/S07_REFCLK1_N: J7.A14
/S07_REFCLK1_P: J7.A15
/S07_SMBCLK_I3CCLK: J7.A7
/S07_SMBDATA_I3CDATA: J7.A8
/S07_SMRST_N: J7.A9
/S07_SW_RX0_N: J7.A17; also elsewhere on the board
/S07_SW_RX0_P: J7.A18; also elsewhere on the board
/S07_SW_RX1_N: J7.A20; also elsewhere on the board
/S07_SW_RX1_P: J7.A21; also elsewhere on the board
/S07_SW_RX2_N: J7.A23; also elsewhere on the board
/S07_SW_RX2_P: J7.A24; also elsewhere on the board
/S07_SW_RX3_N: J7.A26; also elsewhere on the board
/S07_SW_RX3_P: J7.A27; also elsewhere on the board
/S07_SW_TX0_N: J7.B17; also elsewhere on the board
/S07_SW_TX0_P: J7.B18; also elsewhere on the board
/S07_SW_TX1_N: J7.B20; also elsewhere on the board
/S07_SW_TX1_P: J7.B21; also elsewhere on the board
/S07_SW_TX2_N: J7.B23; also elsewhere on the board
/S07_SW_TX2_P: J7.B24; also elsewhere on the board
/S07_SW_TX3_N: J7.B26; also elsewhere on the board
/S07_SW_TX3_P: J7.B27; also elsewhere on the board
/S08_DUALPORTEN_N: J8.B9
/S08_LED: J8.A10
/S08_PERST0_N: J8.B10
/S08_PERST1_CLKREQ_N: J8.A11
/S08_PRSNT0_N: J8.A12
/S08_PWRDIS: J8.B12
/S08_REFCLK0_N: J8.B14; also elsewhere on the board
/S08_REFCLK0_P: J8.B15; also elsewhere on the board
/S08_REFCLK1_N: J8.A14
/S08_REFCLK1_P: J8.A15
/S08_SMBCLK_I3CCLK: J8.A7
/S08_SMBDATA_I3CDATA: J8.A8
/S08_SMRST_N: J8.A9
/S08_SW_RX0_N: J8.A17; also elsewhere on the board
/S08_SW_RX0_P: J8.A18; also elsewhere on the board
/S08_SW_RX1_N: J8.A20; also elsewhere on the board
/S08_SW_RX1_P: J8.A21; also elsewhere on the board
/S08_SW_RX2_N: J8.A23; also elsewhere on the board
/S08_SW_RX2_P: J8.A24; also elsewhere on the board
/S08_SW_RX3_N: J8.A26; also elsewhere on the board
/S08_SW_RX3_P: J8.A27; also elsewhere on the board
/S08_SW_TX0_N: J8.B17; also elsewhere on the board
/S08_SW_TX0_P: J8.B18; also elsewhere on the board
/S08_SW_TX1_N: J8.B20; also elsewhere on the board
/S08_SW_TX1_P: J8.B21; also elsewhere on the board
/S08_SW_TX2_N: J8.B23; also elsewhere on the board
/S08_SW_TX2_P: J8.B24; also elsewhere on the board
/S08_SW_TX3_N: J8.B26; also elsewhere on the board
/S08_SW_TX3_P: J8.B27; also elsewhere on the board
/S09_DUALPORTEN_N: J9.B9
/S09_LED: J9.A10
/S09_PERST0_N: J9.B10
/S09_PERST1_CLKREQ_N: J9.A11
/S09_PRSNT0_N: J9.A12
/S09_PWRDIS: J9.B12
/S09_REFCLK0_N: J9.B14; also elsewhere on the board
/S09_REFCLK0_P: J9.B15; also elsewhere on the board
/S09_REFCLK1_N: J9.A14
/S09_REFCLK1_P: J9.A15
/S09_SMBCLK_I3CCLK: J9.A7
/S09_SMBDATA_I3CDATA: J9.A8
/S09_SMRST_N: J9.A9
/S09_SW_RX0_N: J9.A17; also elsewhere on the board
/S09_SW_RX0_P: J9.A18; also elsewhere on the board
/S09_SW_RX1_N: J9.A20; also elsewhere on the board
/S09_SW_RX1_P: J9.A21; also elsewhere on the board
/S09_SW_RX2_N: J9.A23; also elsewhere on the board
/S09_SW_RX2_P: J9.A24; also elsewhere on the board
/S09_SW_RX3_N: J9.A26; also elsewhere on the board
/S09_SW_RX3_P: J9.A27; also elsewhere on the board
/S09_SW_TX0_N: J9.B17; also elsewhere on the board
/S09_SW_TX0_P: J9.B18; also elsewhere on the board
/S09_SW_TX1_N: J9.B20; also elsewhere on the board
/S09_SW_TX1_P: J9.B21; also elsewhere on the board
/S09_SW_TX2_N: J9.B23; also elsewhere on the board
/S09_SW_TX2_P: J9.B24; also elsewhere on the board
/S09_SW_TX3_N: J9.B26; also elsewhere on the board
/S09_SW_TX3_P: J9.B27; also elsewhere on the board
/S10_DUALPORTEN_N: J10.B9
/S10_LED: J10.A10
/S10_PERST0_N: J10.B10
/S10_PERST1_CLKREQ_N: J10.A11
/S10_PRSNT0_N: J10.A12
/S10_PWRDIS: J10.B12
/S10_REFCLK0_N: J10.B14; also elsewhere on the board
/S10_REFCLK0_P: J10.B15; also elsewhere on the board
/S10_REFCLK1_N: J10.A14
/S10_REFCLK1_P: J10.A15
/S10_SMBCLK_I3CCLK: J10.A7
/S10_SMBDATA_I3CDATA: J10.A8
/S10_SMRST_N: J10.A9
/S10_SW_RX0_N: J10.A17; also elsewhere on the board
/S10_SW_RX0_P: J10.A18; also elsewhere on the board
/S10_SW_RX1_N: J10.A20; also elsewhere on the board
/S10_SW_RX1_P: J10.A21; also elsewhere on the board
/S10_SW_RX2_N: J10.A23; also elsewhere on the board
/S10_SW_RX2_P: J10.A24; also elsewhere on the board
/S10_SW_RX3_N: J10.A26; also elsewhere on the board
/S10_SW_RX3_P: J10.A27; also elsewhere on the board
/S10_SW_TX0_N: J10.B17; also elsewhere on the board
/S10_SW_TX0_P: J10.B18; also elsewhere on the board
/S10_SW_TX1_N: J10.B20; also elsewhere on the board
/S10_SW_TX1_P: J10.B21; also elsewhere on the board
/S10_SW_TX2_N: J10.B23; also elsewhere on the board
/S10_SW_TX2_P: J10.B24; also elsewhere on the board
/S10_SW_TX3_N: J10.B26; also elsewhere on the board
/S10_SW_TX3_P: J10.B27; also elsewhere on the board
/VIN_A: J11.1; also elsewhere on the board
/VIN_B: J12.1; also elsewhere on the board

Schematic: Connectivity_16.kicad_sch, Main_10E1S / Connectivity 16

Parts:
J103: M1 TX1; Twinax_85R_Solder_DRAFT
J104: M1 RX1; Twinax_85R_Solder_DRAFT
J105: M1 TX2; Twinax_85R_Solder_DRAFT
J106: M1 RX2; Twinax_85R_Solder_DRAFT
J107: M1 TX3; Twinax_85R_Solder_DRAFT
J108: M1 RX3; Twinax_85R_Solder_DRAFT
J109: M1 CLK; Twinax_85R_Solder_DRAFT
J110: M2 TX0; Twinax_85R_Solder_DRAFT
J111: M2 RX0; Twinax_85R_Solder_DRAFT
J112: M2 TX1; Twinax_85R_Solder_DRAFT
J113: M2 RX1; Twinax_85R_Solder_DRAFT
J114: M2 TX2; Twinax_85R_Solder_DRAFT

Connections:
/GND: J103.G, J104.G, J105.G, J106.G, J107.G, J108.G, J109.G, J110.G, J111.G, J112.G, J113.G, J114.G; also elsewhere on the board
/M1_CLK_N: J109.N; also elsewhere on the board
/M1_CLK_P: J109.P; also elsewhere on the board
/M1_RX1_N: J104.N; also elsewhere on the board
/M1_RX1_P: J104.P; also elsewhere on the board
/M1_RX2_N: J106.N; also elsewhere on the board
/M1_RX2_P: J106.P; also elsewhere on the board
/M1_RX3_N: J108.N; also elsewhere on the board
/M1_RX3_P: J108.P; also elsewhere on the board
/M1_TX1_N: J103.N; also elsewhere on the board
/M1_TX1_P: J103.P; also elsewhere on the board
/M1_TX2_N: J105.N; also elsewhere on the board
/M1_TX2_P: J105.P; also elsewhere on the board
/M1_TX3_N: J107.N; also elsewhere on the board
/M1_TX3_P: J107.P; also elsewhere on the board
/M2_RX0_N: J111.N; also elsewhere on the board
/M2_RX0_P: J111.P; also elsewhere on the board
/M2_RX1_N: J113.N; also elsewhere on the board
/M2_RX1_P: J113.P; also elsewhere on the board
/M2_TX0_N: J110.N; also elsewhere on the board
/M2_TX0_P: J110.P; also elsewhere on the board
/M2_TX1_N: J112.N; also elsewhere on the board
/M2_TX1_P: J112.P; also elsewhere on the board
/M2_TX2_N: J114.N; also elsewhere on the board
/M2_TX2_P: J114.P; also elsewhere on the board

Schematic: Connectivity_17.kicad_sch, Main_10E1S / Connectivity 17

Parts:
J115: M2 RX2; Twinax_85R_Solder_DRAFT
J116: M2 TX3; Twinax_85R_Solder_DRAFT
J117: M2 RX3; Twinax_85R_Solder_DRAFT
J118: M2 CLK; Twinax_85R_Solder_DRAFT
J119: M4 TX0; Twinax_85R_Solder_DRAFT
J120: M4 RX0; Twinax_85R_Solder_DRAFT
J121: M4 TX1; Twinax_85R_Solder_DRAFT
J122: M4 RX1; Twinax_85R_Solder_DRAFT
J123: M4 TX2; Twinax_85R_Solder_DRAFT
J124: M4 RX2; Twinax_85R_Solder_DRAFT
J125: M4 TX3; Twinax_85R_Solder_DRAFT
J126: M4 RX3; Twinax_85R_Solder_DRAFT

Connections:
/GND: J115.G, J116.G, J117.G, J118.G, J119.G, J120.G, J121.G, J122.G, J123.G, J124.G, J125.G, J126.G; also elsewhere on the board
/M2_CLK_N: J118.N; also elsewhere on the board
/M2_CLK_P: J118.P; also elsewhere on the board
/M2_RX2_N: J115.N; also elsewhere on the board
/M2_RX2_P: J115.P; also elsewhere on the board
/M2_RX3_N: J117.N; also elsewhere on the board
/M2_RX3_P: J117.P; also elsewhere on the board
/M2_TX3_N: J116.N; also elsewhere on the board
/M2_TX3_P: J116.P; also elsewhere on the board
/M4_RX0_N: J120.N; also elsewhere on the board
/M4_RX0_P: J120.P; also elsewhere on the board
/M4_RX1_N: J122.N; also elsewhere on the board
/M4_RX1_P: J122.P; also elsewhere on the board
/M4_RX2_N: J124.N; also elsewhere on the board
/M4_RX2_P: J124.P; also elsewhere on the board
/M4_RX3_N: J126.N; also elsewhere on the board
/M4_RX3_P: J126.P; also elsewhere on the board
/M4_TX0_N: J119.N; also elsewhere on the board
/M4_TX0_P: J119.P; also elsewhere on the board
/M4_TX1_N: J121.N; also elsewhere on the board
/M4_TX1_P: J121.P; also elsewhere on the board
/M4_TX2_N: J123.N; also elsewhere on the board
/M4_TX2_P: J123.P; also elsewhere on the board
/M4_TX3_N: J125.N; also elsewhere on the board
/M4_TX3_P: J125.P; also elsewhere on the board

Schematic: Connectivity_18.kicad_sch, Main_10E1S / Connectivity 18

Parts:
J127: M4 CLK; Twinax_85R_Solder_DRAFT
J201: M3 TX0; Twinax_85R_Solder_DRAFT
J202: M3 RX0; Twinax_85R_Solder_DRAFT
J203: M3 TX1; Twinax_85R_Solder_DRAFT
J204: M3 RX1; Twinax_85R_Solder_DRAFT
J205: M3 TX2; Twinax_85R_Solder_DRAFT
J206: M3 RX2; Twinax_85R_Solder_DRAFT
J207: M3 TX3; Twinax_85R_Solder_DRAFT
J208: M3 RX3; Twinax_85R_Solder_DRAFT
J209: M3 CLK; Twinax_85R_Solder_DRAFT
J210: UP TX0; Twinax_85R_Solder_DRAFT
J211: UP RX0; Twinax_85R_Solder_DRAFT

Connections:
/GND: J127.G, J201.G, J202.G, J203.G, J204.G, J205.G, J206.G, J207.G, J208.G, J209.G, J210.G, J211.G; also elsewhere on the board
/M3_CLK_N: J209.N; also elsewhere on the board
/M3_CLK_P: J209.P; also elsewhere on the board
/M3_RX0_N: J202.N; also elsewhere on the board
/M3_RX0_P: J202.P; also elsewhere on the board
/M3_RX1_N: J204.N; also elsewhere on the board
/M3_RX1_P: J204.P; also elsewhere on the board
/M3_RX2_N: J206.N; also elsewhere on the board
/M3_RX2_P: J206.P; also elsewhere on the board
/M3_RX3_N: J208.N; also elsewhere on the board
/M3_RX3_P: J208.P; also elsewhere on the board
/M3_TX0_N: J201.N; also elsewhere on the board
/M3_TX0_P: J201.P; also elsewhere on the board
/M3_TX1_N: J203.N; also elsewhere on the board
/M3_TX1_P: J203.P; also elsewhere on the board
/M3_TX2_N: J205.N; also elsewhere on the board
/M3_TX2_P: J205.P; also elsewhere on the board
/M3_TX3_N: J207.N; also elsewhere on the board
/M3_TX3_P: J207.P; also elsewhere on the board
/M4_CLK_N: J127.N; also elsewhere on the board
/M4_CLK_P: J127.P; also elsewhere on the board
/UP_RX0_N: J211.N; also elsewhere on the board
/UP_RX0_P: J211.P; also elsewhere on the board
/UP_TX0_N: J210.N; also elsewhere on the board
/UP_TX0_P: J210.P; also elsewhere on the board

Schematic: Connectivity_19.kicad_sch, Main_10E1S / Connectivity 19

Parts:
J212: UP TX1; Twinax_85R_Solder_DRAFT
J213: UP RX1; Twinax_85R_Solder_DRAFT
J214: UP TX2; Twinax_85R_Solder_DRAFT
J215: UP RX2; Twinax_85R_Solder_DRAFT
J216: UP TX3; Twinax_85R_Solder_DRAFT
J217: UP RX3; Twinax_85R_Solder_DRAFT
J218: UP CLK; Twinax_85R_Solder_DRAFT
J219: M5 TX0; Twinax_85R_Solder_DRAFT
J220: M5 RX0; Twinax_85R_Solder_DRAFT
J221: M5 TX1; Twinax_85R_Solder_DRAFT
J222: M5 RX1; Twinax_85R_Solder_DRAFT
J223: M5 TX2; Twinax_85R_Solder_DRAFT

Connections:
/GND: J212.G, J213.G, J214.G, J215.G, J216.G, J217.G, J218.G, J219.G, J220.G, J221.G, J222.G, J223.G; also elsewhere on the board
/M5_RX0_N: J220.N; also elsewhere on the board
/M5_RX0_P: J220.P; also elsewhere on the board
/M5_RX1_N: J222.N; also elsewhere on the board
/M5_RX1_P: J222.P; also elsewhere on the board
/M5_TX0_N: J219.N; also elsewhere on the board
/M5_TX0_P: J219.P; also elsewhere on the board
/M5_TX1_N: J221.N; also elsewhere on the board
/M5_TX1_P: J221.P; also elsewhere on the board
/M5_TX2_N: J223.N; also elsewhere on the board
/M5_TX2_P: J223.P; also elsewhere on the board
/UP_CLK_N: J218.N
/UP_CLK_P: J218.P
/UP_RX1_N: J213.N; also elsewhere on the board
/UP_RX1_P: J213.P; also elsewhere on the board
/UP_RX2_N: J215.N; also elsewhere on the board
/UP_RX2_P: J215.P; also elsewhere on the board
/UP_RX3_N: J217.N; also elsewhere on the board
/UP_RX3_P: J217.P; also elsewhere on the board
/UP_TX1_N: J212.N; also elsewhere on the board
/UP_TX1_P: J212.P; also elsewhere on the board
/UP_TX2_N: J214.N; also elsewhere on the board
/UP_TX2_P: J214.P; also elsewhere on the board
/UP_TX3_N: J216.N; also elsewhere on the board
/UP_TX3_P: J216.P; also elsewhere on the board

Schematic: Connectivity_20.kicad_sch, Main_10E1S / Connectivity 20

Parts:
J224: M5 RX2; Twinax_85R_Solder_DRAFT
J225: M5 TX3; Twinax_85R_Solder_DRAFT
J226: M5 RX3; Twinax_85R_Solder_DRAFT
J227: M5 CLK; Twinax_85R_Solder_DRAFT
J301: 12V protected / GND / 5A design target; Wire_12V_GND_3A
J302: 12V protected / GND; Wire_12V_GND_3A
J303, J304: Three x4 port control / 12-wire; Control_12_Wire
J401: CUSTOM 12V POWER / SMT SHELL DRAFT; USB_C_24P_Vertical_SMT_Shell_7p46_CUSTOM_DRAFT
J402: TB5 PORT / SMT SHELL DRAFT / PART TBD; USB_C_24P_Vertical_SMT_Shell_7p46_CUSTOM_DRAFT
L31: 2.2uH; L_Coilcraft_XAL4020-XXX
R101: 76.1k; R_0402_1005Metric

Connections:
/BUCK_SW: L31.1; also elsewhere on the board
/CABLE12_L: J301.1; also elsewhere on the board
/CABLE12_R: J302.1; also elsewhere on the board
/CUSTOM_12V_RAW: J401.A4, J401.A6, J401.A7, J401.A8, J401.A9, J401.B4, J401.B6, J401.B7, J401.B8, J401.B9
/CUSTOM_DET_A: J401.A5; also elsewhere on the board
/CUSTOM_DET_B: J401.B5; also elsewhere on the board
/GND: J224.G, J225.G, J226.G, J227.G, J301.2, J302.2, J303.10, J303.11, J303.12, J304.10, J304.11, J304.12, J401.A1, J401.A2, J401.A3, J401.A10, J401.A11, J401.A12, J401.B1, J401.B2, J401.B3, J401.B10, J401.B11, J401.B12, J401.SH, J402.A1, J402.A12, J402.B1, J402.B12, J402.SH; also elsewhere on the board
/M1_CLKREQ: J303.2
/M1_PERST: J303.1
/M1_WAKE: J303.3
/M2_CLKREQ: J303.5
/M2_PERST: J303.4
/M2_WAKE: J303.6
/M3_CLKREQ: J304.2
/M3_PERST: J304.1
/M3_WAKE: J304.3
/M4_CLKREQ: J303.8
/M4_PERST: J303.7
/M4_WAKE: J303.9
/M5_CLKREQ: J304.8
/M5_CLK_N: J227.N; also elsewhere on the board
/M5_CLK_P: J227.P; also elsewhere on the board
/M5_PERST: J304.7
/M5_RX2_N: J224.N; also elsewhere on the board
/M5_RX2_P: J224.P; also elsewhere on the board
/M5_RX3_N: J226.N; also elsewhere on the board
/M5_RX3_P: J226.P; also elsewhere on the board
/M5_TX3_N: J225.N; also elsewhere on the board
/M5_TX3_P: J225.P; also elsewhere on the board
/M5_WAKE: J304.9
/P3V3_AUX: L31.2; also elsewhere on the board
/S01_PWR_UV: R101.2; also elsewhere on the board
/TB5_CC1: J402.A5
/TB5_CC2: J402.B5
/TB5_RX1_N: J402.B10
/TB5_RX1_P: J402.B11
/TB5_RX2_N: J402.A10
/TB5_RX2_P: J402.A11
/TB5_SBU1: J402.A8
/TB5_SBU2: J402.B8
/TB5_TX1_N: J402.A3
/TB5_TX1_P: J402.A2
/TB5_TX2_N: J402.B3
/TB5_TX2_P: J402.B2
/TB5_USB2_DN: J402.A7, J402.B7
/TB5_USB2_DP: J402.A6, J402.B6
/TB5_VBUS: J402.A4, J402.A9, J402.B4, J402.B9
/UP_CLKREQ: J304.5
/UP_PERST: J304.4
/UP_WAKE: J304.6
/VBANK_A: R101.1; also elsewhere on the board

Schematic: Connectivity_21.kicad_sch, Main_10E1S / Connectivity 21

Parts:
R102, R104, R107, R109, R112: 10k; R_0402_1005Metric
R103, R108, R113: 102k; R_0402_1005Metric
R105, R110: 1.10k; R_0402_1005Metric
R106, R111: 76.1k; R_0402_1005Metric

Connections:
/GND: R102.2, R104.2, R105.2, R107.2, R109.2, R110.2, R112.2; also elsewhere on the board
/S01_PWR_ILM: R105.1; also elsewhere on the board
/S01_PWR_OV: R103.2, R104.1; also elsewhere on the board
/S01_PWR_UV: R102.1; also elsewhere on the board
/S02_PWR_ILM: R110.1; also elsewhere on the board
/S02_PWR_OV: R108.2, R109.1; also elsewhere on the board
/S02_PWR_UV: R106.2, R107.1; also elsewhere on the board
/S03_PWR_OV: R113.2; also elsewhere on the board
/S03_PWR_UV: R111.2, R112.1; also elsewhere on the board
/VBANK_A: R103.1, R106.1, R108.1, R111.1, R113.1; also elsewhere on the board

Schematic: Connectivity_22.kicad_sch, Main_10E1S / Connectivity 22

Parts:
R114, R117, R119, R122, R124: 10k; R_0402_1005Metric
R115, R120, R125: 1.10k; R_0402_1005Metric
R116, R121: 76.1k; R_0402_1005Metric
R118, R123: 102k; R_0402_1005Metric

Connections:
/GND: R114.2, R115.2, R117.2, R119.2, R120.2, R122.2, R124.2, R125.2; also elsewhere on the board
/S03_PWR_ILM: R115.1; also elsewhere on the board
/S03_PWR_OV: R114.1; also elsewhere on the board
/S04_PWR_ILM: R120.1; also elsewhere on the board
/S04_PWR_OV: R118.2, R119.1; also elsewhere on the board
/S04_PWR_UV: R116.2, R117.1; also elsewhere on the board
/S05_PWR_ILM: R125.1; also elsewhere on the board
/S05_PWR_OV: R123.2, R124.1; also elsewhere on the board
/S05_PWR_UV: R121.2, R122.1; also elsewhere on the board
/VBANK_A: R116.1, R118.1, R121.1, R123.1; also elsewhere on the board

Schematic: Connectivity_23.kicad_sch, Main_10E1S / Connectivity 23

Parts:
R126, R131, R136: 76.1k; R_0402_1005Metric
R127, R129, R132, R134, R137: 10k; R_0402_1005Metric
R128, R133: 102k; R_0402_1005Metric
R130, R135: 1.10k; R_0402_1005Metric

Connections:
/GND: R127.2, R129.2, R130.2, R132.2, R134.2, R135.2, R137.2; also elsewhere on the board
/S06_PWR_ILM: R130.1; also elsewhere on the board
/S06_PWR_OV: R128.2, R129.1; also elsewhere on the board
/S06_PWR_UV: R126.2, R127.1; also elsewhere on the board
/S07_PWR_ILM: R135.1; also elsewhere on the board
/S07_PWR_OV: R133.2, R134.1; also elsewhere on the board
/S07_PWR_UV: R131.2, R132.1; also elsewhere on the board
/S08_PWR_UV: R136.2, R137.1; also elsewhere on the board
/VBANK_B: R126.1, R128.1, R131.1, R133.1, R136.1; also elsewhere on the board

Schematic: Connectivity_24.kicad_sch, Main_10E1S / Connectivity 24

Parts:
R138, R143, R148: 102k; R_0402_1005Metric
R139, R142, R144, R147, R149: 10k; R_0402_1005Metric
R140, R145: 1.10k; R_0402_1005Metric
R141, R146: 76.1k; R_0402_1005Metric

Connections:
/GND: R139.2, R140.2, R142.2, R144.2, R145.2, R147.2, R149.2; also elsewhere on the board
/S08_PWR_ILM: R140.1; also elsewhere on the board
/S08_PWR_OV: R138.2, R139.1; also elsewhere on the board
/S09_PWR_ILM: R145.1; also elsewhere on the board
/S09_PWR_OV: R143.2, R144.1; also elsewhere on the board
/S09_PWR_UV: R141.2, R142.1; also elsewhere on the board
/S10_PWR_OV: R148.2, R149.1; also elsewhere on the board
/S10_PWR_UV: R146.2, R147.1; also elsewhere on the board
/VBANK_B: R138.1, R141.1, R143.1, R146.1, R148.1; also elsewhere on the board

Schematic: Connectivity_25.kicad_sch, Main_10E1S / Connectivity 25

Parts:
R150: 1.10k; R_0402_1005Metric
R301, R411: 76.1k; R_0402_1005Metric
R302, R304, R412: 10k; R_0402_1005Metric
R303, R413: 102k; R_0402_1005Metric
R305: 3.32k; R_0402_1005Metric
R311, R401, R402: 100k; R_0402_1005Metric

Connections:
/AUX_ILM: R305.1; also elsewhere on the board
/AUX_OV: R303.2, R304.1; also elsewhere on the board
/AUX_PG: R311.2; also elsewhere on the board
/AUX_UV: R301.2, R302.1; also elsewhere on the board
/CUSTOM_DET_A: R401.1; also elsewhere on the board
/CUSTOM_DET_B: R402.1; also elsewhere on the board
/EXT_41_OV: R413.2; also elsewhere on the board
/EXT_41_UV: R411.2, R412.1; also elsewhere on the board
/GND: R150.2, R302.2, R304.2, R305.2, R401.2, R402.2, R412.2; also elsewhere on the board
/P3V3_AUX: R311.1; also elsewhere on the board
/S10_PWR_ILM: R150.1; also elsewhere on the board
/VBANK_A: R301.1, R303.1; also elsewhere on the board
/VIN_A: R411.1, R413.1; also elsewhere on the board

Schematic: Connectivity_26.kicad_sch, Main_10E1S / Connectivity 26

Parts:
R414, R422, R424, R702, R703, R704: 10k; R_0402_1005Metric
R415: 665R 1% / ILIM 5.0A; R_0402_1005Metric
R421: 76.1k; R_0402_1005Metric
R423: 102k; R_0402_1005Metric
R425: 953R 1% / ILIM 3.5A; R_0402_1005Metric
R701: 22R provisional SI tuning; R_0402_1005Metric
R705: 180R 1% / Intel clock topology; R_0402_1005Metric

Connections:
/CPU_CLK_RCOMP: R705.1; also elsewhere on the board
/CPU_SPI_CLK_FLASH: R701.2; also elsewhere on the board
/CPU_SPI_CLK_PAD: R701.1; also elsewhere on the board
/CPU_SPI_CS0_N: R702.1; also elsewhere on the board
/CPU_SPI_IO2: R703.1; also elsewhere on the board
/CPU_SPI_IO3: R704.1; also elsewhere on the board
/CPU_VCCPRIM_1P8: R702.2, R703.2, R704.2; also elsewhere on the board
/EXT_41_ILM: R415.1; also elsewhere on the board
/EXT_41_OV: R414.1; also elsewhere on the board
/EXT_42_ILM: R425.1; also elsewhere on the board
/EXT_42_OV: R423.2, R424.1; also elsewhere on the board
/EXT_42_UV: R421.2, R422.1; also elsewhere on the board
/GND: R414.2, R415.2, R422.2, R424.2, R425.2, R705.2; also elsewhere on the board
/VIN_B: R421.1, R423.1; also elsewhere on the board

Schematic: Connectivity_27.kicad_sch, Main_10E1S / Connectivity 27

Parts:
R706, R707: TBD RCOMP / DNP / Intel PDG required; R_0402_1005Metric; not fitted
R708, R709: 200R 1%; R_0402_1005Metric
R710, R711: 100k; R_0402_1005Metric
R712, R713: 10k; R_0402_1005Metric
R714, R715, R716: 0R / request clock always on; R_0402_1005Metric
R721: 0R analog supply link / filter pending; R_0402_1005Metric

Connections:
/CLKBUF1_VDDA: R721.2; also elsewhere on the board
/CPU_CLKREQ0_N: R714.1; also elsewhere on the board
/CPU_CLKREQ1_N: R715.1; also elsewhere on the board
/CPU_CLKREQ2_N: R716.1; also elsewhere on the board
/CPU_PCIE4_RCOMP: R706.1; also elsewhere on the board
/CPU_PCIE5_RCOMP: R707.1; also elsewhere on the board
/CPU_PWRBTN_1V8_N: R713.1; also elsewhere on the board
/CPU_RTCRST_N: R710.1; also elsewhere on the board
/CPU_SRTCRST_N: R711.1; also elsewhere on the board
/CPU_SYS_RESET_1V8_N: R712.1; also elsewhere on the board
/CPU_USB2_RCOMP: R708.1; also elsewhere on the board
/CPU_USB32_RCOMP: R709.1; also elsewhere on the board
/CPU_VCCPRIM_1P8: R712.2, R713.2; also elsewhere on the board
/CPU_VCCRTC: R710.2, R711.2; also elsewhere on the board
/GND: R706.2, R707.2, R708.2, R709.2, R714.2, R715.2, R716.2; also elsewhere on the board
/P3V3_AUX: R721.1; also elsewhere on the board

Schematic: Connectivity_28.kicad_sch, Main_10E1S / Connectivity 28

Parts:
R722: 0R analog supply link / filter pending; R_0402_1005Metric
R724, R725: 10k; R_0402_1005Metric
R730, R731, R732: DNP / filter link pending Intel PDG; R_0402_1005Metric; not fitted
R740, R741, R742, R743, R744, R745: 10k / Intel required external bias; R_0402_1005Metric

Connections:
/CLKBUF2_VDDA: R722.2; also elsewhere on the board
/CPU_ACPRESENT: R741.1; also elsewhere on the board
/CPU_BATLOW_N: R740.1; also elsewhere on the board
/CPU_PERST_1V8_N: R725.1; also elsewhere on the board
/CPU_PLT_PWROK: R745.1; also elsewhere on the board
/CPU_PMCALERT_N: R742.1; also elsewhere on the board
/CPU_RSMRST_N: R744.1; also elsewhere on the board
/CPU_VCCPRIM_1P8: R725.2, R730.1, R731.1, R740.2, R741.2, R742.2, R743.2; also elsewhere on the board
/CPU_VCCPRIM_1P8_FLTRA_IN: R730.2; also elsewhere on the board
/CPU_VCCPRIM_1P8_FLTRB_IN: R731.2; also elsewhere on the board
/CPU_VCCPRIM_VNNAON: R732.1; also elsewhere on the board
/CPU_VCCPRIM_VNNAON_FLTR: R732.2; also elsewhere on the board
/CPU_WAKE_N: R743.1; also elsewhere on the board
/GND: R744.2, R745.2; also elsewhere on the board
/P3V3_AUX: R722.1; also elsewhere on the board
/PEX_1V8: R724.2; also elsewhere on the board
/PEX_SYS_RESET_N: R724.1; also elsewhere on the board

Schematic: Connectivity_29.kicad_sch, Main_10E1S / Connectivity 29

Parts:
R746: 10k / Intel required external bias; R_0402_1005Metric
TP701: PROBE /CPU_SVID_CLK_1V25; Probe_0p5mm
TP702: PROBE /CPU_SVID_DATA_1V25; Probe_0p5mm
TP703: PROBE /CPU_SVID_ALERT_1V25_N; Probe_0p5mm
TP704: PROBE /CPU_PLT_PWROK; Probe_0p5mm
TP705: PROBE /CPU_SYS_PWROK_1V8; Probe_0p5mm
TP706: PROBE /CPU_RSMRST_N; Probe_0p5mm
TP707: PROBE /CPU_SYS_RESET_1V8_N; Probe_0p5mm
TP708: PROBE /CPU_PWRBTN_1V8_N; Probe_0p5mm
TP709: PROBE /CPU_VCCST_EN_1V8; Probe_0p5mm
TP710: PROBE /CPU_SLP_S3_1V8_N; Probe_0p5mm
TP711: PROBE /CPU_SLP_S4_1V8_N; Probe_0p5mm

Connections:
/CPU_PLT_PWROK: TP704.1; also elsewhere on the board
/CPU_PWRBTN_1V8_N: TP708.1; also elsewhere on the board
/CPU_RSMRST_N: TP706.1; also elsewhere on the board
/CPU_SLP_S3_1V8_N: TP710.1; also elsewhere on the board
/CPU_SLP_S4_1V8_N: TP711.1; also elsewhere on the board
/CPU_SVID_ALERT_1V25_N: TP703.1; also elsewhere on the board
/CPU_SVID_CLK_1V25: TP701.1; also elsewhere on the board
/CPU_SVID_DATA_1V25: TP702.1; also elsewhere on the board
/CPU_SYS_PWROK_1V8: R746.1, TP705.1; also elsewhere on the board
/CPU_SYS_RESET_1V8_N: TP707.1; also elsewhere on the board
/CPU_VCCST_EN_1V8: TP709.1; also elsewhere on the board
/GND: R746.2; also elsewhere on the board

Schematic: Connectivity_30.kicad_sch, Main_10E1S / Connectivity 30

Parts:
TP712: PROBE /CPU_SLP_S5_1V8_N; Probe_0p5mm
U11, U12, U13, U14, U15, U16, U17, U18, U19, U20, U30: TPS259470ARPWR; TI_RPW0010A_TPS25947

Connections:
/AUX_12V_PROTECTED: U30.6; also elsewhere on the board
/AUX_DVDT: U30.7; also elsewhere on the board
/AUX_ILM: U30.9; also elsewhere on the board
/AUX_OV: U30.2; also elsewhere on the board
/AUX_UV: U30.1; also elsewhere on the board
/CPU_SLP_S5_1V8_N: TP712.1; also elsewhere on the board
/GND: U11.8, U12.8, U13.8, U14.8, U15.8, U16.8, U17.8, U18.8, U19.8, U20.8, U30.8; also elsewhere on the board
/P12_SLOT01: U11.6; also elsewhere on the board
/P12_SLOT02: U12.6; also elsewhere on the board
/P12_SLOT03: U13.6; also elsewhere on the board
/P12_SLOT04: U14.6; also elsewhere on the board
/P12_SLOT05: U15.6; also elsewhere on the board
/P12_SLOT06: U16.6; also elsewhere on the board
/P12_SLOT07: U17.6; also elsewhere on the board
/P12_SLOT08: U18.6; also elsewhere on the board
/P12_SLOT09: U19.6; also elsewhere on the board
/P12_SLOT10: U20.6; also elsewhere on the board
/S01_PWR_DVDT: U11.7; also elsewhere on the board
/S01_PWR_ILM: U11.9; also elsewhere on the board
/S01_PWR_OV: U11.2; also elsewhere on the board
/S01_PWR_UV: U11.1; also elsewhere on the board
/S02_PWR_DVDT: U12.7; also elsewhere on the board
/S02_PWR_ILM: U12.9; also elsewhere on the board
/S02_PWR_OV: U12.2; also elsewhere on the board
/S02_PWR_UV: U12.1; also elsewhere on the board
/S03_PWR_DVDT: U13.7; also elsewhere on the board
/S03_PWR_ILM: U13.9; also elsewhere on the board
/S03_PWR_OV: U13.2; also elsewhere on the board
/S03_PWR_UV: U13.1; also elsewhere on the board
/S04_PWR_DVDT: U14.7; also elsewhere on the board
/S04_PWR_ILM: U14.9; also elsewhere on the board
/S04_PWR_OV: U14.2; also elsewhere on the board
/S04_PWR_UV: U14.1; also elsewhere on the board
/S05_PWR_DVDT: U15.7; also elsewhere on the board
/S05_PWR_ILM: U15.9; also elsewhere on the board
/S05_PWR_OV: U15.2; also elsewhere on the board
/S05_PWR_UV: U15.1; also elsewhere on the board
/S06_PWR_DVDT: U16.7; also elsewhere on the board
/S06_PWR_ILM: U16.9; also elsewhere on the board
/S06_PWR_OV: U16.2; also elsewhere on the board
/S06_PWR_UV: U16.1; also elsewhere on the board
/S07_PWR_DVDT: U17.7; also elsewhere on the board
/S07_PWR_ILM: U17.9; also elsewhere on the board
/S07_PWR_OV: U17.2; also elsewhere on the board
/S07_PWR_UV: U17.1; also elsewhere on the board
/S08_PWR_DVDT: U18.7; also elsewhere on the board
/S08_PWR_ILM: U18.9; also elsewhere on the board
/S08_PWR_OV: U18.2; also elsewhere on the board
/S08_PWR_UV: U18.1; also elsewhere on the board
/S09_PWR_DVDT: U19.7; also elsewhere on the board
/S09_PWR_ILM: U19.9; also elsewhere on the board
/S09_PWR_OV: U19.2; also elsewhere on the board
/S09_PWR_UV: U19.1; also elsewhere on the board
/S10_PWR_DVDT: U20.7; also elsewhere on the board
/S10_PWR_ILM: U20.9; also elsewhere on the board
/S10_PWR_OV: U20.2; also elsewhere on the board
/S10_PWR_UV: U20.1; also elsewhere on the board
/VBANK_A: U11.5, U12.5, U13.5, U14.5, U15.5, U30.5; also elsewhere on the board
/VBANK_B: U16.5, U17.5, U18.5, U19.5, U20.5; also elsewhere on the board
