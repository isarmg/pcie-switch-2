# Repository isarmg/pcie-switch-2 (continued)

## KiCad design outputs/PCIe_3board_RevK/Main_10E1S/Main_10E1S.kicad_pcb (continued)

Schematic: Connectivity_07.kicad_sch, Main_10E1S / Connectivity 07

Parts:
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10: HSEC6-028-01-S-DV-WT-TR; Samtec_HSEC6-028-01-S-DV-WT
J11: 12V 15A FEED A; WireSolder_2x_8x5_P12
J12: 12V 15A FEED B; WireSolder_2x_8x5_P12

Connections:
/GND: J1.A1, J1.A2, J1.A3, J1.A4, J1.A5, J1.A6, J1.A13, J1.A16, J1.A19, J1.A22, J1.A25, J1.A28, J1.B13, J1.B16, J1.B19, J1.B22, J1.B25, J1.B28, J2.A1, J2.A2, J2.A3, J2.A4, J2.A5, J2.A6, J2.A13, J2.A16, J2.A19, J2.A22, J2.A25, J2.A28, J2.B13, J2.B16, J2.B19, J2.B22, J2.B25, J2.B28, J3.A1, J3.A2, J3.A3, J3.A4, J3.A5, J3.A6, J3.A13, J3.A16, J3.A19, J3.A22, J3.A25, J3.A28, J3.B13, J3.B16, J3.B19, J3.B22, J3.B25, J3.B28, J4.A1, J4.A2, J4.A3, J4.A4, J4.A5, J4.A6, J4.A13, J4.A16, J4.A19, J4.A22, J4.A25, J4.A28, J4.B13, J4.B16, J4.B19, J4.B22, J4.B25, J4.B28, J5.A1, J5.A2, J5.A3, J5.A4, J5.A5, J5.A6, J5.A13, J5.A16, J5.A19, J5.A22, J5.A25, J5.A28, J5.B13, J5.B16, J5.B19, J5.B22, J5.B25, J5.B28, J6.A1, J6.A2, J6.A3, J6.A4, J6.A5, J6.A6, J6.A13, J6.A16, J6.A19, J6.A22, J6.A25, J6.A28, J6.B13, J6.B16, J6.B19, J6.B22, J6.B25, J6.B28, J7.A1, J7.A2, J7.A3, J7.A4, J7.A5, J7.A6, J7.A13, J7.A16, J7.A19, J7.A22, J7.A25, J7.A28, J7.B13, J7.B16, J7.B19, J7.B22, J7.B25, J7.B28, J8.A1, J8.A2, J8.A3, J8.A4, J8.A5, J8.A6, J8.A13, J8.A16, J8.A19, J8.A22, J8.A25, J8.A28, J8.B13, J8.B16, J8.B19, J8.B22, J8.B25, J8.B28, J9.A1, J9.A2, J9.A3, J9.A4, J9.A5, J9.A6, J9.A13, J9.A16, J9.A19, J9.A22, J9.A25, J9.A28, J9.B13, J9.B16, J9.B19, J9.B22, J9.B25, J9.B28, J10.A1, J10.A2, J10.A3, J10.A4, J10.A5, J10.A6, J10.A13, J10.A16, J10.A19, J10.A22, J10.A25, J10.A28, J10.B13, J10.B16, J10.B19, J10.B22, J10.B25, J10.B28, J11.2, J12.2; also elsewhere on the board
/P3V3_AUX: J1.B11, J2.B11, J3.B11, J4.B11, J5.B11, J6.B11, J7.B11, J8.B11, J9.B11, J10.B11; also elsewhere on the board
/P12_SLOT01: J1.B1, J1.B2, J1.B3, J1.B4, J1.B5, J1.B6; also elsewhere on the board
/P12_SLOT02: J2.B1, J2.B2, J2.B3, J2.B4, J2.B5, J2.B6; also elsewhere on the board
/P12_SLOT03: J3.B1, J3.B2, J3.B3, J3.B4, J3.B5, J3.B6; also elsewhere on the board
/P12_SLOT04: J4.B1, J4.B2, J4.B3, J4.B4, J4.B5, J4.B6; also elsewhere on the board
/P12_SLOT05: J5.B1, J5.B2, J5.B3, J5.B4, J5.B5, J5.B6; also elsewhere on the board
/P12_SLOT06: J6.B1, J6.B2, J6.B3, J6.B4, J6.B5, J6.B6; also elsewhere on the board
/P12_SLOT07: J7.B1, J7.B2, J7.B3, J7.B4, J7.B5, J7.B6; also elsewhere on the board
/P12_SLOT08: J8.B1, J8.B2, J8.B3, J8.B4, J8.B5, J8.B6; also elsewhere on the board
/P12_SLOT09: J9.B1, J9.B2, J9.B3, J9.B4, J9.B5, J9.B6; also elsewhere on the board
/P12_SLOT10: J10.B1, J10.B2, J10.B3, J10.B4, J10.B5, J10.B6; also elsewhere on the board
/S01_DUALPORTEN_N: J1.B9
/S01_LED: J1.A10
/S01_PERST0_N: J1.B10
/S01_PERST1_CLKREQ_N: J1.A11
/S01_PRSNT0_N: J1.A12
/S01_PWRDIS: J1.B12
/S01_REFCLK0_N: J1.B14
/S01_REFCLK0_P: J1.B15
/S01_REFCLK1_N: J1.A14
/S01_REFCLK1_P: J1.A15
/S01_SMBCLK_I3CCLK: J1.A7
/S01_SMBDATA_I3CDATA: J1.A8
/S01_SMRST_N: J1.A9
/S01_SW_RX0_N: J1.A17; also elsewhere on the board
/S01_SW_RX0_P: J1.A18; also elsewhere on the board
/S01_SW_RX1_N: J1.A20; also elsewhere on the board
/S01_SW_RX1_P: J1.A21; also elsewhere on the board
/S01_SW_RX2_N: J1.A23; also elsewhere on the board
/S01_SW_RX2_P: J1.A24; also elsewhere on the board
/S01_SW_RX3_N: J1.A26; also elsewhere on the board
/S01_SW_RX3_P: J1.A27; also elsewhere on the board
/S01_SW_TX0_N: J1.B17; also elsewhere on the board
/S01_SW_TX0_P: J1.B18; also elsewhere on the board
/S01_SW_TX1_N: J1.B20; also elsewhere on the board
/S01_SW_TX1_P: J1.B21; also elsewhere on the board
/S01_SW_TX2_N: J1.B23; also elsewhere on the board
/S01_SW_TX2_P: J1.B24; also elsewhere on the board
/S01_SW_TX3_N: J1.B26; also elsewhere on the board
/S01_SW_TX3_P: J1.B27; also elsewhere on the board
/S02_DUALPORTEN_N: J2.B9
/S02_LED: J2.A10
/S02_PERST0_N: J2.B10
/S02_PERST1_CLKREQ_N: J2.A11
/S02_PRSNT0_N: J2.A12
/S02_PWRDIS: J2.B12
/S02_REFCLK0_N: J2.B14
/S02_REFCLK0_P: J2.B15
/S02_REFCLK1_N: J2.A14
/S02_REFCLK1_P: J2.A15
/S02_SMBCLK_I3CCLK: J2.A7
/S02_SMBDATA_I3CDATA: J2.A8
/S02_SMRST_N: J2.A9
/S02_SW_RX0_N: J2.A17; also elsewhere on the board
/S02_SW_RX0_P: J2.A18; also elsewhere on the board
/S02_SW_RX1_N: J2.A20; also elsewhere on the board
/S02_SW_RX1_P: J2.A21; also elsewhere on the board
/S02_SW_RX2_N: J2.A23; also elsewhere on the board
/S02_SW_RX2_P: J2.A24; also elsewhere on the board
/S02_SW_RX3_N: J2.A26; also elsewhere on the board
/S02_SW_RX3_P: J2.A27; also elsewhere on the board
/S02_SW_TX0_N: J2.B17; also elsewhere on the board
/S02_SW_TX0_P: J2.B18; also elsewhere on the board
/S02_SW_TX1_N: J2.B20; also elsewhere on the board
/S02_SW_TX1_P: J2.B21; also elsewhere on the board
/S02_SW_TX2_N: J2.B23; also elsewhere on the board
/S02_SW_TX2_P: J2.B24; also elsewhere on the board
/S02_SW_TX3_N: J2.B26; also elsewhere on the board
/S02_SW_TX3_P: J2.B27; also elsewhere on the board
/S03_DUALPORTEN_N: J3.B9
/S03_LED: J3.A10
/S03_PERST0_N: J3.B10
/S03_PERST1_CLKREQ_N: J3.A11
/S03_PRSNT0_N: J3.A12
/S03_PWRDIS: J3.B12
/S03_REFCLK0_N: J3.B14
/S03_REFCLK0_P: J3.B15
/S03_REFCLK1_N: J3.A14
/S03_REFCLK1_P: J3.A15
/S03_SMBCLK_I3CCLK: J3.A7
/S03_SMBDATA_I3CDATA: J3.A8
/S03_SMRST_N: J3.A9
/S03_SW_RX0_N: J3.A17; also elsewhere on the board
/S03_SW_RX0_P: J3.A18; also elsewhere on the board
/S03_SW_RX1_N: J3.A20; also elsewhere on the board
/S03_SW_RX1_P: J3.A21; also elsewhere on the board
/S03_SW_RX2_N: J3.A23; also elsewhere on the board
/S03_SW_RX2_P: J3.A24; also elsewhere on the board
/S03_SW_RX3_N: J3.A26; also elsewhere on the board
/S03_SW_RX3_P: J3.A27; also elsewhere on the board
/S03_SW_TX0_N: J3.B17; also elsewhere on the board
/S03_SW_TX0_P: J3.B18; also elsewhere on the board
/S03_SW_TX1_N: J3.B20; also elsewhere on the board
/S03_SW_TX1_P: J3.B21; also elsewhere on the board
/S03_SW_TX2_N: J3.B23; also elsewhere on the board
/S03_SW_TX2_P: J3.B24; also elsewhere on the board
/S03_SW_TX3_N: J3.B26; also elsewhere on the board
/S03_SW_TX3_P: J3.B27; also elsewhere on the board
/S04_DUALPORTEN_N: J4.B9
/S04_LED: J4.A10
/S04_PERST0_N: J4.B10
/S04_PERST1_CLKREQ_N: J4.A11
/S04_PRSNT0_N: J4.A12
/S04_PWRDIS: J4.B12
/S04_REFCLK0_N: J4.B14
/S04_REFCLK0_P: J4.B15
/S04_REFCLK1_N: J4.A14
/S04_REFCLK1_P: J4.A15
/S04_SMBCLK_I3CCLK: J4.A7
/S04_SMBDATA_I3CDATA: J4.A8
/S04_SMRST_N: J4.A9
/S04_SW_RX0_N: J4.A17; also elsewhere on the board
/S04_SW_RX0_P: J4.A18; also elsewhere on the board
/S04_SW_RX1_N: J4.A20; also elsewhere on the board
/S04_SW_RX1_P: J4.A21; also elsewhere on the board
/S04_SW_RX2_N: J4.A23; also elsewhere on the board
/S04_SW_RX2_P: J4.A24; also elsewhere on the board
/S04_SW_RX3_N: J4.A26; also elsewhere on the board
/S04_SW_RX3_P: J4.A27; also elsewhere on the board
/S04_SW_TX0_N: J4.B17; also elsewhere on the board
/S04_SW_TX0_P: J4.B18; also elsewhere on the board
/S04_SW_TX1_N: J4.B20; also elsewhere on the board
/S04_SW_TX1_P: J4.B21; also elsewhere on the board
/S04_SW_TX2_N: J4.B23; also elsewhere on the board
/S04_SW_TX2_P: J4.B24; also elsewhere on the board
/S04_SW_TX3_N: J4.B26; also elsewhere on the board
/S04_SW_TX3_P: J4.B27; also elsewhere on the board
/S05_DUALPORTEN_N: J5.B9
/S05_LED: J5.A10
/S05_PERST0_N: J5.B10
/S05_PERST1_CLKREQ_N: J5.A11
/S05_PRSNT0_N: J5.A12
/S05_PWRDIS: J5.B12
/S05_REFCLK0_N: J5.B14
/S05_REFCLK0_P: J5.B15
/S05_REFCLK1_N: J5.A14
/S05_REFCLK1_P: J5.A15
/S05_SMBCLK_I3CCLK: J5.A7
/S05_SMBDATA_I3CDATA: J5.A8
/S05_SMRST_N: J5.A9
/S05_SW_RX0_N: J5.A17; also elsewhere on the board
/S05_SW_RX0_P: J5.A18; also elsewhere on the board
/S05_SW_RX1_N: J5.A20; also elsewhere on the board
/S05_SW_RX1_P: J5.A21; also elsewhere on the board
/S05_SW_RX2_N: J5.A23; also elsewhere on the board
/S05_SW_RX2_P: J5.A24; also elsewhere on the board
/S05_SW_RX3_N: J5.A26; also elsewhere on the board
/S05_SW_RX3_P: J5.A27; also elsewhere on the board
/S05_SW_TX0_N: J5.B17; also elsewhere on the board
/S05_SW_TX0_P: J5.B18; also elsewhere on the board
/S05_SW_TX1_N: J5.B20; also elsewhere on the board
/S05_SW_TX1_P: J5.B21; also elsewhere on the board
/S05_SW_TX2_N: J5.B23; also elsewhere on the board
/S05_SW_TX2_P: J5.B24; also elsewhere on the board
/S05_SW_TX3_N: J5.B26; also elsewhere on the board
/S05_SW_TX3_P: J5.B27; also elsewhere on the board
/S06_DUALPORTEN_N: J6.B9
/S06_LED: J6.A10
/S06_PERST0_N: J6.B10
/S06_PERST1_CLKREQ_N: J6.A11
/S06_PRSNT0_N: J6.A12
/S06_PWRDIS: J6.B12
/S06_REFCLK0_N: J6.B14
/S06_REFCLK0_P: J6.B15
/S06_REFCLK1_N: J6.A14
/S06_REFCLK1_P: J6.A15
/S06_SMBCLK_I3CCLK: J6.A7
/S06_SMBDATA_I3CDATA: J6.A8
/S06_SMRST_N: J6.A9
/S06_SW_RX0_N: J6.A17; also elsewhere on the board
/S06_SW_RX0_P: J6.A18; also elsewhere on the board
/S06_SW_RX1_N: J6.A20; also elsewhere on the board
/S06_SW_RX1_P: J6.A21; also elsewhere on the board
/S06_SW_RX2_N: J6.A23; also elsewhere on the board
/S06_SW_RX2_P: J6.A24; also elsewhere on the board
/S06_SW_RX3_N: J6.A26; also elsewhere on the board
/S06_SW_RX3_P: J6.A27; also elsewhere on the board
/S06_SW_TX0_N: J6.B17; also elsewhere on the board
/S06_SW_TX0_P: J6.B18; also elsewhere on the board
/S06_SW_TX1_N: J6.B20; also elsewhere on the board
/S06_SW_TX1_P: J6.B21; also elsewhere on the board
/S06_SW_TX2_N: J6.B23; also elsewhere on the board
/S06_SW_TX2_P: J6.B24; also elsewhere on the board
/S06_SW_TX3_N: J6.B26; also elsewhere on the board
/S06_SW_TX3_P: J6.B27; also elsewhere on the board
/S07_DUALPORTEN_N: J7.B9
/S07_LED: J7.A10
/S07_PERST0_N: J7.B10
/S07_PERST1_CLKREQ_N: J7.A11
/S07_PRSNT0_N: J7.A12
/S07_PWRDIS: J7.B12
/S07_REFCLK0_N: J7.B14
/S07_REFCLK0_P: J7.B15
/S07_REFCLK1_N: J7.A14
/S07_REFCLK1_P: J7.A15
/S07_SMBCLK_I3CCLK: J7.A7
/S07_SMBDATA_I3CDATA: J7.A8
/S07_SMRST_N: J7.A9
/S07_SW_RX0_N: J7.A17; also elsewhere on the board
/S07_SW_RX0_P: J7.A18; also elsewhere on the board
/S07_SW_RX1_N: J7.A20; also elsewhere on the board
/S07_SW_RX1_P: J7.A21; also elsewhere on the board
/S07_SW_RX2_N: J7.A23; also elsewhere on the board
/S07_SW_RX2_P: J7.A24; also elsewhere on the board
/S07_SW_RX3_N: J7.A26; also elsewhere on the board
/S07_SW_RX3_P: J7.A27; also elsewhere on the board
/S07_SW_TX0_N: J7.B17; also elsewhere on the board
/S07_SW_TX0_P: J7.B18; also elsewhere on the board
/S07_SW_TX1_N: J7.B20; also elsewhere on the board
/S07_SW_TX1_P: J7.B21; also elsewhere on the board
/S07_SW_TX2_N: J7.B23; also elsewhere on the board
/S07_SW_TX2_P: J7.B24; also elsewhere on the board
/S07_SW_TX3_N: J7.B26; also elsewhere on the board
/S07_SW_TX3_P: J7.B27; also elsewhere on the board
/S08_DUALPORTEN_N: J8.B9
/S08_LED: J8.A10
/S08_PERST0_N: J8.B10
/S08_PERST1_CLKREQ_N: J8.A11
/S08_PRSNT0_N: J8.A12
/S08_PWRDIS: J8.B12
/S08_REFCLK0_N: J8.B14
/S08_REFCLK0_P: J8.B15
/S08_REFCLK1_N: J8.A14
/S08_REFCLK1_P: J8.A15
/S08_SMBCLK_I3CCLK: J8.A7
/S08_SMBDATA_I3CDATA: J8.A8
/S08_SMRST_N: J8.A9
/S08_SW_RX0_N: J8.A17; also elsewhere on the board
/S08_SW_RX0_P: J8.A18; also elsewhere on the board
/S08_SW_RX1_N: J8.A20; also elsewhere on the board
/S08_SW_RX1_P: J8.A21; also elsewhere on the board
/S08_SW_RX2_N: J8.A23; also elsewhere on the board
/S08_SW_RX2_P: J8.A24; also elsewhere on the board
/S08_SW_RX3_N: J8.A26; also elsewhere on the board
/S08_SW_RX3_P: J8.A27; also elsewhere on the board
/S08_SW_TX0_N: J8.B17; also elsewhere on the board
/S08_SW_TX0_P: J8.B18; also elsewhere on the board
/S08_SW_TX1_N: J8.B20; also elsewhere on the board
/S08_SW_TX1_P: J8.B21; also elsewhere on the board
/S08_SW_TX2_N: J8.B23; also elsewhere on the board
/S08_SW_TX2_P: J8.B24; also elsewhere on the board
/S08_SW_TX3_N: J8.B26; also elsewhere on the board
/S08_SW_TX3_P: J8.B27; also elsewhere on the board
/S09_DUALPORTEN_N: J9.B9
/S09_LED: J9.A10
/S09_PERST0_N: J9.B10
/S09_PERST1_CLKREQ_N: J9.A11
/S09_PRSNT0_N: J9.A12
/S09_PWRDIS: J9.B12
/S09_REFCLK0_N: J9.B14
/S09_REFCLK0_P: J9.B15
/S09_REFCLK1_N: J9.A14
/S09_REFCLK1_P: J9.A15
/S09_SMBCLK_I3CCLK: J9.A7
/S09_SMBDATA_I3CDATA: J9.A8
/S09_SMRST_N: J9.A9
/S09_SW_RX0_N: J9.A17; also elsewhere on the board
/S09_SW_RX0_P: J9.A18; also elsewhere on the board
/S09_SW_RX1_N: J9.A20; also elsewhere on the board
/S09_SW_RX1_P: J9.A21; also elsewhere on the board
/S09_SW_RX2_N: J9.A23; also elsewhere on the board
/S09_SW_RX2_P: J9.A24; also elsewhere on the board
/S09_SW_RX3_N: J9.A26; also elsewhere on the board
/S09_SW_RX3_P: J9.A27; also elsewhere on the board
/S09_SW_TX0_N: J9.B17; also elsewhere on the board
/S09_SW_TX0_P: J9.B18; also elsewhere on the board
/S09_SW_TX1_N: J9.B20; also elsewhere on the board
/S09_SW_TX1_P: J9.B21; also elsewhere on the board
/S09_SW_TX2_N: J9.B23; also elsewhere on the board
/S09_SW_TX2_P: J9.B24; also elsewhere on the board
/S09_SW_TX3_N: J9.B26; also elsewhere on the board
/S09_SW_TX3_P: J9.B27; also elsewhere on the board
/S10_DUALPORTEN_N: J10.B9
/S10_LED: J10.A10
/S10_PERST0_N: J10.B10
/S10_PERST1_CLKREQ_N: J10.A11
/S10_PRSNT0_N: J10.A12
/S10_PWRDIS: J10.B12
/S10_REFCLK0_N: J10.B14
/S10_REFCLK0_P: J10.B15
/S10_REFCLK1_N: J10.A14
/S10_REFCLK1_P: J10.A15
/S10_SMBCLK_I3CCLK: J10.A7
/S10_SMBDATA_I3CDATA: J10.A8
/S10_SMRST_N: J10.A9
/S10_SW_RX0_N: J10.A17; also elsewhere on the board
/S10_SW_RX0_P: J10.A18; also elsewhere on the board
/S10_SW_RX1_N: J10.A20; also elsewhere on the board
/S10_SW_RX1_P: J10.A21; also elsewhere on the board
/S10_SW_RX2_N: J10.A23; also elsewhere on the board
/S10_SW_RX2_P: J10.A24; also elsewhere on the board
/S10_SW_RX3_N: J10.A26; also elsewhere on the board
/S10_SW_RX3_P: J10.A27; also elsewhere on the board
/S10_SW_TX0_N: J10.B17; also elsewhere on the board
/S10_SW_TX0_P: J10.B18; also elsewhere on the board
/S10_SW_TX1_N: J10.B20; also elsewhere on the board
/S10_SW_TX1_P: J10.B21; also elsewhere on the board
/S10_SW_TX2_N: J10.B23; also elsewhere on the board
/S10_SW_TX2_P: J10.B24; also elsewhere on the board
/S10_SW_TX3_N: J10.B26; also elsewhere on the board
/S10_SW_TX3_P: J10.B27; also elsewhere on the board
/VIN_A: J11.1; also elsewhere on the board
/VIN_B: J12.1; also elsewhere on the board

Schematic: Connectivity_08.kicad_sch, Main_10E1S / Connectivity 08

Parts:
J101: M1 TX0; Twinax_85R_Solder_DRAFT
J102: M1 RX0; Twinax_85R_Solder_DRAFT
J103: M1 TX1; Twinax_85R_Solder_DRAFT
J104: M1 RX1; Twinax_85R_Solder_DRAFT
J105: M1 TX2; Twinax_85R_Solder_DRAFT
J106: M1 RX2; Twinax_85R_Solder_DRAFT
J107: M1 TX3; Twinax_85R_Solder_DRAFT
J108: M1 RX3; Twinax_85R_Solder_DRAFT
J109: M1 CLK; Twinax_85R_Solder_DRAFT
J110: M2 TX0; Twinax_85R_Solder_DRAFT
J111: M2 RX0; Twinax_85R_Solder_DRAFT
J112: M2 TX1; Twinax_85R_Solder_DRAFT

Connections:
/GND: J101.G, J102.G, J103.G, J104.G, J105.G, J106.G, J107.G, J108.G, J109.G, J110.G, J111.G, J112.G; also elsewhere on the board
/M1_CLK_N: J109.N
/M1_CLK_P: J109.P
/M1_RX0_N: J102.N; also elsewhere on the board
/M1_RX0_P: J102.P; also elsewhere on the board
/M1_RX1_N: J104.N; also elsewhere on the board
/M1_RX1_P: J104.P; also elsewhere on the board
/M1_RX2_N: J106.N; also elsewhere on the board
/M1_RX2_P: J106.P; also elsewhere on the board
/M1_RX3_N: J108.N; also elsewhere on the board
/M1_RX3_P: J108.P; also elsewhere on the board
/M1_TX0_N: J101.N; also elsewhere on the board
/M1_TX0_P: J101.P; also elsewhere on the board
/M1_TX1_N: J103.N; also elsewhere on the board
/M1_TX1_P: J103.P; also elsewhere on the board
/M1_TX2_N: J105.N; also elsewhere on the board
/M1_TX2_P: J105.P; also elsewhere on the board
/M1_TX3_N: J107.N; also elsewhere on the board
/M1_TX3_P: J107.P; also elsewhere on the board
/M2_RX0_N: J111.N; also elsewhere on the board
/M2_RX0_P: J111.P; also elsewhere on the board
/M2_TX0_N: J110.N; also elsewhere on the board
/M2_TX0_P: J110.P; also elsewhere on the board
/M2_TX1_N: J112.N; also elsewhere on the board
/M2_TX1_P: J112.P; also elsewhere on the board

Schematic: Connectivity_09.kicad_sch, Main_10E1S / Connectivity 09

Parts:
J113: M2 RX1; Twinax_85R_Solder_DRAFT
J114: M2 TX2; Twinax_85R_Solder_DRAFT
J115: M2 RX2; Twinax_85R_Solder_DRAFT
J116: M2 TX3; Twinax_85R_Solder_DRAFT
J117: M2 RX3; Twinax_85R_Solder_DRAFT
J118: M2 CLK; Twinax_85R_Solder_DRAFT
J119: M4 TX0; Twinax_85R_Solder_DRAFT
J120: M4 RX0; Twinax_85R_Solder_DRAFT
J121: M4 TX1; Twinax_85R_Solder_DRAFT
J122: M4 RX1; Twinax_85R_Solder_DRAFT
J123: M4 TX2; Twinax_85R_Solder_DRAFT
J124: M4 RX2; Twinax_85R_Solder_DRAFT

Connections:
/GND: J113.G, J114.G, J115.G, J116.G, J117.G, J118.G, J119.G, J120.G, J121.G, J122.G, J123.G, J124.G; also elsewhere on the board
/M2_CLK_N: J118.N
/M2_CLK_P: J118.P
/M2_RX1_N: J113.N; also elsewhere on the board
/M2_RX1_P: J113.P; also elsewhere on the board
/M2_RX2_N: J115.N; also elsewhere on the board
/M2_RX2_P: J115.P; also elsewhere on the board
/M2_RX3_N: J117.N; also elsewhere on the board
/M2_RX3_P: J117.P; also elsewhere on the board
/M2_TX2_N: J114.N; also elsewhere on the board
/M2_TX2_P: J114.P; also elsewhere on the board
/M2_TX3_N: J116.N; also elsewhere on the board
/M2_TX3_P: J116.P; also elsewhere on the board
/M4_RX0_N: J120.N; also elsewhere on the board
/M4_RX0_P: J120.P; also elsewhere on the board
/M4_RX1_N: J122.N; also elsewhere on the board
/M4_RX1_P: J122.P; also elsewhere on the board
/M4_RX2_N: J124.N; also elsewhere on the board
/M4_RX2_P: J124.P; also elsewhere on the board
/M4_TX0_N: J119.N; also elsewhere on the board
/M4_TX0_P: J119.P; also elsewhere on the board
/M4_TX1_N: J121.N; also elsewhere on the board
/M4_TX1_P: J121.P; also elsewhere on the board
/M4_TX2_N: J123.N; also elsewhere on the board
/M4_TX2_P: J123.P; also elsewhere on the board

Schematic: Connectivity_10.kicad_sch, Main_10E1S / Connectivity 10

Parts:
J125: M4 TX3; Twinax_85R_Solder_DRAFT
J126: M4 RX3; Twinax_85R_Solder_DRAFT
J127: M4 CLK; Twinax_85R_Solder_DRAFT
J201: M3 TX0; Twinax_85R_Solder_DRAFT
J202: M3 RX0; Twinax_85R_Solder_DRAFT
J203: M3 TX1; Twinax_85R_Solder_DRAFT
J204: M3 RX1; Twinax_85R_Solder_DRAFT
J205: M3 TX2; Twinax_85R_Solder_DRAFT
J206: M3 RX2; Twinax_85R_Solder_DRAFT
J207: M3 TX3; Twinax_85R_Solder_DRAFT
J208: M3 RX3; Twinax_85R_Solder_DRAFT
J209: M3 CLK; Twinax_85R_Solder_DRAFT

Connections:
/GND: J125.G, J126.G, J127.G, J201.G, J202.G, J203.G, J204.G, J205.G, J206.G, J207.G, J208.G, J209.G; also elsewhere on the board
/M3_CLK_N: J209.N
/M3_CLK_P: J209.P
/M3_RX0_N: J202.N; also elsewhere on the board
/M3_RX0_P: J202.P; also elsewhere on the board
/M3_RX1_N: J204.N; also elsewhere on the board
/M3_RX1_P: J204.P; also elsewhere on the board
/M3_RX2_N: J206.N; also elsewhere on the board
/M3_RX2_P: J206.P; also elsewhere on the board
/M3_RX3_N: J208.N; also elsewhere on the board
/M3_RX3_P: J208.P; also elsewhere on the board
/M3_TX0_N: J201.N; also elsewhere on the board
/M3_TX0_P: J201.P; also elsewhere on the board
/M3_TX1_N: J203.N; also elsewhere on the board
/M3_TX1_P: J203.P; also elsewhere on the board
/M3_TX2_N: J205.N; also elsewhere on the board
/M3_TX2_P: J205.P; also elsewhere on the board
/M3_TX3_N: J207.N; also elsewhere on the board
/M3_TX3_P: J207.P; also elsewhere on the board
/M4_CLK_N: J127.N
/M4_CLK_P: J127.P
/M4_RX3_N: J126.N; also elsewhere on the board
/M4_RX3_P: J126.P; also elsewhere on the board
/M4_TX3_N: J125.N; also elsewhere on the board
/M4_TX3_P: J125.P; also elsewhere on the board

Schematic: Connectivity_11.kicad_sch, Main_10E1S / Connectivity 11

Parts:
J210: UP TX0; Twinax_85R_Solder_DRAFT
J211: UP RX0; Twinax_85R_Solder_DRAFT
J212: UP TX1; Twinax_85R_Solder_DRAFT
J213: UP RX1; Twinax_85R_Solder_DRAFT
J214: UP TX2; Twinax_85R_Solder_DRAFT
J215: UP RX2; Twinax_85R_Solder_DRAFT
J216: UP TX3; Twinax_85R_Solder_DRAFT
J217: UP RX3; Twinax_85R_Solder_DRAFT
J218: UP CLK; Twinax_85R_Solder_DRAFT
J219: M5 TX0; Twinax_85R_Solder_DRAFT
J220: M5 RX0; Twinax_85R_Solder_DRAFT
J221: M5 TX1; Twinax_85R_Solder_DRAFT

Connections:
/GND: J210.G, J211.G, J212.G, J213.G, J214.G, J215.G, J216.G, J217.G, J218.G, J219.G, J220.G, J221.G; also elsewhere on the board
/M5_RX0_N: J220.N; also elsewhere on the board
/M5_RX0_P: J220.P; also elsewhere on the board
/M5_TX0_N: J219.N; also elsewhere on the board
/M5_TX0_P: J219.P; also elsewhere on the board
/M5_TX1_N: J221.N; also elsewhere on the board
/M5_TX1_P: J221.P; also elsewhere on the board
/UP_CLK_N: J218.N
/UP_CLK_P: J218.P
/UP_RX0_N: J211.N; also elsewhere on the board
/UP_RX0_P: J211.P; also elsewhere on the board
/UP_RX1_N: J213.N; also elsewhere on the board
/UP_RX1_P: J213.P; also elsewhere on the board
/UP_RX2_N: J215.N; also elsewhere on the board
/UP_RX2_P: J215.P; also elsewhere on the board
/UP_RX3_N: J217.N; also elsewhere on the board
/UP_RX3_P: J217.P; also elsewhere on the board
/UP_TX0_N: J210.N; also elsewhere on the board
/UP_TX0_P: J210.P; also elsewhere on the board
/UP_TX1_N: J212.N; also elsewhere on the board
/UP_TX1_P: J212.P; also elsewhere on the board
/UP_TX2_N: J214.N; also elsewhere on the board
/UP_TX2_P: J214.P; also elsewhere on the board
/UP_TX3_N: J216.N; also elsewhere on the board
/UP_TX3_P: J216.P; also elsewhere on the board

Schematic: Connectivity_12.kicad_sch, Main_10E1S / Connectivity 12

Parts:
J222: M5 RX1; Twinax_85R_Solder_DRAFT
J223: M5 TX2; Twinax_85R_Solder_DRAFT
J224: M5 RX2; Twinax_85R_Solder_DRAFT
J225: M5 TX3; Twinax_85R_Solder_DRAFT
J226: M5 RX3; Twinax_85R_Solder_DRAFT
J227: M5 CLK; Twinax_85R_Solder_DRAFT
J301: 12V protected / GND / 5A design target; Wire_12V_GND_3A
J302: 12V protected / GND; Wire_12V_GND_3A
J303, J304: Three x4 port control / 12-wire; Control_12_Wire
J401: CUSTOM 12V POWER / NOT USB; GCT_USB4160_24P_Vertical_7p46_DRAFT_TB5_UNQUALIFIED
J402: THUNDERBOLT 5 / SI PART TBD; GCT_USB4160_24P_Vertical_7p46_DRAFT_TB5_UNQUALIFIED

Connections:
/CABLE12_L: J301.1; also elsewhere on the board
/CABLE12_R: J302.1; also elsewhere on the board
/CUSTOM_12V_RAW: J401.A4, J401.A6, J401.A7, J401.A8, J401.A9, J401.B4, J401.B6, J401.B7, J401.B8, J401.B9
/CUSTOM_DET_A: J401.A5; also elsewhere on the board
/CUSTOM_DET_B: J401.B5; also elsewhere on the board
/GND: J222.G, J223.G, J224.G, J225.G, J226.G, J227.G, J301.2, J302.2, J303.10, J303.11, J303.12, J304.10, J304.11, J304.12, J401.A1, J401.A2, J401.A3, J401.A10, J401.A11, J401.A12, J401.B1, J401.B2, J401.B3, J401.B10, J401.B11, J401.B12, J401.SH, J402.A1, J402.A12, J402.B1, J402.B12, J402.SH; also elsewhere on the board
/M1_CLKREQ: J303.2
/M1_PERST: J303.1
/M1_WAKE: J303.3
/M2_CLKREQ: J303.5
/M2_PERST: J303.4
/M2_WAKE: J303.6
/M3_CLKREQ: J304.2
/M3_PERST: J304.1
/M3_WAKE: J304.3
/M4_CLKREQ: J303.8
/M4_PERST: J303.7
/M4_WAKE: J303.9
/M5_CLKREQ: J304.8
/M5_CLK_N: J227.N
/M5_CLK_P: J227.P
/M5_PERST: J304.7
/M5_RX1_N: J222.N; also elsewhere on the board
/M5_RX1_P: J222.P; also elsewhere on the board
/M5_RX2_N: J224.N; also elsewhere on the board
/M5_RX2_P: J224.P; also elsewhere on the board
/M5_RX3_N: J226.N; also elsewhere on the board
/M5_RX3_P: J226.P; also elsewhere on the board
/M5_TX2_N: J223.N; also elsewhere on the board
/M5_TX2_P: J223.P; also elsewhere on the board
/M5_TX3_N: J225.N; also elsewhere on the board
/M5_TX3_P: J225.P; also elsewhere on the board
/M5_WAKE: J304.9
/TB5_CC1: J402.A5
/TB5_CC2: J402.B5
/TB5_RX1_N: J402.B10
/TB5_RX1_P: J402.B11
/TB5_RX2_N: J402.A10
/TB5_RX2_P: J402.A11
/TB5_SBU1: J402.A8
/TB5_SBU2: J402.B8
/TB5_TX1_N: J402.A3
/TB5_TX1_P: J402.A2
/TB5_TX2_N: J402.B3
/TB5_TX2_P: J402.B2
/TB5_USB2_DN: J402.A7, J402.B7
/TB5_USB2_DP: J402.A6, J402.B6
/TB5_VBUS: J402.A4, J402.A9, J402.B4, J402.B9
/UP_CLKREQ: J304.5
/UP_PERST: J304.4
/UP_WAKE: J304.6

Schematic: Connectivity_13.kicad_sch, Main_10E1S / Connectivity 13

Parts:
L31: 2.2uH; L_Coilcraft_XAL4020-XXX
R101, R106, R111: 76.1k; R_0402_1005Metric
R102, R104, R107, R109: 10k; R_0402_1005Metric
R103, R108: 102k; R_0402_1005Metric
R105, R110: 1.10k; R_0402_1005Metric

Connections:
/BUCK_SW: L31.1; also elsewhere on the board
/GND: R102.2, R104.2, R105.2, R107.2, R109.2, R110.2; also elsewhere on the board
/P3V3_AUX: L31.2; also elsewhere on the board
/S01_PWR_ILM: R105.1; also elsewhere on the board
/S01_PWR_OV: R103.2, R104.1; also elsewhere on the board
/S01_PWR_UV: R101.2, R102.1; also elsewhere on the board
/S02_PWR_ILM: R110.1; also elsewhere on the board
/S02_PWR_OV: R108.2, R109.1; also elsewhere on the board
/S02_PWR_UV: R106.2, R107.1; also elsewhere on the board
/S03_PWR_UV: R111.2; also elsewhere on the board
/VBANK_A: R101.1, R103.1, R106.1, R108.1, R111.1; also elsewhere on the board

Schematic: Connectivity_14.kicad_sch, Main_10E1S / Connectivity 14

Parts:
R112, R114, R117, R119, R122: 10k; R_0402_1005Metric
R113, R118, R123: 102k; R_0402_1005Metric
R115, R120: 1.10k; R_0402_1005Metric
R116, R121: 76.1k; R_0402_1005Metric

Connections:
/GND: R112.2, R114.2, R115.2, R117.2, R119.2, R120.2, R122.2; also elsewhere on the board
/S03_PWR_ILM: R115.1; also elsewhere on the board
/S03_PWR_OV: R113.2, R114.1; also elsewhere on the board
/S03_PWR_UV: R112.1; also elsewhere on the board
/S04_PWR_ILM: R120.1; also elsewhere on the board
/S04_PWR_OV: R118.2, R119.1; also elsewhere on the board
/S04_PWR_UV: R116.2, R117.1; also elsewhere on the board
/S05_PWR_OV: R123.2; also elsewhere on the board
/S05_PWR_UV: R121.2, R122.1; also elsewhere on the board
/VBANK_A: R113.1, R116.1, R118.1, R121.1, R123.1; also elsewhere on the board

Schematic: Connectivity_15.kicad_sch, Main_10E1S / Connectivity 15

Parts:
R124, R127, R129, R132, R134: 10k; R_0402_1005Metric
R125, R130, R135: 1.10k; R_0402_1005Metric
R126, R131: 76.1k; R_0402_1005Metric
R128, R133: 102k; R_0402_1005Metric

Connections:
/GND: R124.2, R125.2, R127.2, R129.2, R130.2, R132.2, R134.2, R135.2; also elsewhere on the board
/S05_PWR_ILM: R125.1; also elsewhere on the board
/S05_PWR_OV: R124.1; also elsewhere on the board
/S06_PWR_ILM: R130.1; also elsewhere on the board
/S06_PWR_OV: R128.2, R129.1; also elsewhere on the board
/S06_PWR_UV: R126.2, R127.1; also elsewhere on the board
/S07_PWR_ILM: R135.1; also elsewhere on the board
/S07_PWR_OV: R133.2, R134.1; also elsewhere on the board
/S07_PWR_UV: R131.2, R132.1; also elsewhere on the board
/VBANK_B: R126.1, R128.1, R131.1, R133.1; also elsewhere on the board

Schematic: Connectivity_16.kicad_sch, Main_10E1S / Connectivity 16

Parts:
R136, R141, R146: 76.1k; R_0402_1005Metric
R137, R139, R142, R144, R147: 10k; R_0402_1005Metric
R138, R143: 102k; R_0402_1005Metric
R140, R145: 1.10k; R_0402_1005Metric

Connections:
/GND: R137.2, R139.2, R140.2, R142.2, R144.2, R145.2, R147.2; also elsewhere on the board
/S08_PWR_ILM: R140.1; also elsewhere on the board
/S08_PWR_OV: R138.2, R139.1; also elsewhere on the board
/S08_PWR_UV: R136.2, R137.1; also elsewhere on the board
/S09_PWR_ILM: R145.1; also elsewhere on the board
/S09_PWR_OV: R143.2, R144.1; also elsewhere on the board
/S09_PWR_UV: R141.2, R142.1; also elsewhere on the board
/S10_PWR_UV: R146.2, R147.1; also elsewhere on the board
/VBANK_B: R136.1, R138.1, R141.1, R143.1, R146.1; also elsewhere on the board

Schematic: Connectivity_17.kicad_sch, Main_10E1S / Connectivity 17

Parts:
R148, R303: 102k; R_0402_1005Metric
R149, R302, R304: 10k; R_0402_1005Metric
R150: 1.10k; R_0402_1005Metric
R301, R411: 76.1k; R_0402_1005Metric
R305: 3.32k; R_0402_1005Metric
R311, R401, R402: 100k; R_0402_1005Metric

Connections:
/AUX_ILM: R305.1; also elsewhere on the board
/AUX_OV: R303.2, R304.1; also elsewhere on the board
/AUX_PG: R311.2; also elsewhere on the board
/AUX_UV: R301.2, R302.1; also elsewhere on the board
/CUSTOM_DET_A: R401.1; also elsewhere on the board
/CUSTOM_DET_B: R402.1; also elsewhere on the board
/EXT_41_UV: R411.2; also elsewhere on the board
/GND: R149.2, R150.2, R302.2, R304.2, R305.2, R401.2, R402.2; also elsewhere on the board
/P3V3_AUX: R311.1; also elsewhere on the board
/S10_PWR_ILM: R150.1; also elsewhere on the board
/S10_PWR_OV: R148.2, R149.1; also elsewhere on the board
/VBANK_A: R301.1, R303.1; also elsewhere on the board
/VBANK_B: R148.1; also elsewhere on the board
/VIN_A: R411.1; also elsewhere on the board

Schematic: Connectivity_18.kicad_sch, Main_10E1S / Connectivity 18

Parts:
R412, R414, R422, R424: 10k; R_0402_1005Metric
R413, R423: 102k; R_0402_1005Metric
R415: 665R 1% / ILIM 5.0A; R_0402_1005Metric
R421: 76.1k; R_0402_1005Metric
R425: 953R 1% / ILIM 3.5A; R_0402_1005Metric
U11, U12, U13: TPS259470ARPWR; TI_RPW0010A_TPS25947

Connections:
/EXT_41_ILM: R415.1; also elsewhere on the board
/EXT_41_OV: R413.2, R414.1; also elsewhere on the board
/EXT_41_UV: R412.1; also elsewhere on the board
/EXT_42_ILM: R425.1; also elsewhere on the board
/EXT_42_OV: R423.2, R424.1; also elsewhere on the board
/EXT_42_UV: R421.2, R422.1; also elsewhere on the board
/GND: R412.2, R414.2, R415.2, R422.2, R424.2, R425.2, U11.8, U12.8, U13.8; also elsewhere on the board
/P12_SLOT01: U11.6; also elsewhere on the board
/P12_SLOT02: U12.6; also elsewhere on the board
/P12_SLOT03: U13.6; also elsewhere on the board
/S01_PWR_DVDT: U11.7; also elsewhere on the board
/S01_PWR_ILM: U11.9; also elsewhere on the board
/S01_PWR_OV: U11.2; also elsewhere on the board
/S01_PWR_UV: U11.1; also elsewhere on the board
/S02_PWR_DVDT: U12.7; also elsewhere on the board
/S02_PWR_ILM: U12.9; also elsewhere on the board
/S02_PWR_OV: U12.2; also elsewhere on the board
/S02_PWR_UV: U12.1; also elsewhere on the board
/S03_PWR_DVDT: U13.7; also elsewhere on the board
/S03_PWR_ILM: U13.9; also elsewhere on the board
/S03_PWR_OV: U13.2; also elsewhere on the board
/S03_PWR_UV: U13.1; also elsewhere on the board
/VBANK_A: U11.5, U12.5, U13.5; also elsewhere on the board
/VIN_A: R413.1; also elsewhere on the board
/VIN_B: R421.1, R423.1; also elsewhere on the board

Schematic: Connectivity_19.kicad_sch, Main_10E1S / Connectivity 19

Parts:
U14, U15, U16, U17, U18, U19, U20, U30, U41, U42: TPS259470ARPWR; TI_RPW0010A_TPS25947
U31: TPS62132RGTR; VQFN-16-1EP_3x3mm_P0.5mm_EP1.68x1.68mm
U601: 9ZXL0851EKILFT / SUPPORT NETWORK PENDING; REF_9ZXL0851EKILFT_KU1

Connections:
/AUX_12V_PROTECTED: U30.6, U31.10, U31.11, U31.12, U31.13; also elsewhere on the board
/AUX_DVDT: U30.7; also elsewhere on the board
/AUX_ILM: U30.9; also elsewhere on the board
/AUX_OV: U30.2; also elsewhere on the board
/AUX_PG: U31.4; also elsewhere on the board
/AUX_UV: U30.1; also elsewhere on the board
/BUCK_SS: U31.9; also elsewhere on the board
/BUCK_SW: U31.1, U31.2, U31.3; also elsewhere on the board
/CABLE12_L: U41.6; also elsewhere on the board
/CABLE12_R: U42.6; also elsewhere on the board
/EXT_41_DVDT: U41.7; also elsewhere on the board
/EXT_41_ILM: U41.9; also elsewhere on the board
/EXT_41_OV: U41.2; also elsewhere on the board
/EXT_41_UV: U41.1; also elsewhere on the board
/EXT_42_DVDT: U42.7; also elsewhere on the board
/EXT_42_ILM: U42.9; also elsewhere on the board
/EXT_42_OV: U42.2; also elsewhere on the board
/EXT_42_UV: U42.1; also elsewhere on the board
/GND: U14.8, U15.8, U16.8, U17.8, U18.8, U19.8, U20.8, U30.8, U31.5, U31.6, U31.7, U31.8, U31.15, U31.16, U31.17, U41.8, U42.8, U601.2 (GNDR), U601.49 (GND); also elsewhere on the board
/P3V3_AUX: U31.14; also elsewhere on the board
/P12_SLOT04: U14.6; also elsewhere on the board
/P12_SLOT05: U15.6; also elsewhere on the board
/P12_SLOT06: U16.6; also elsewhere on the board
/P12_SLOT07: U17.6; also elsewhere on the board
/P12_SLOT08: U18.6; also elsewhere on the board
/P12_SLOT09: U19.6; also elsewhere on the board
/P12_SLOT10: U20.6; also elsewhere on the board
/REF_KC_100_133M: U601.47 (^100M_133M#)
/REF_KC_BYP#_HIBW_: U601.48 (^HIBW_BYPM_LOBW#)
/REF_KC_CK_PD#: U601.1 (^CKPWRGD_PD#)
/REF_KC_DIF0N: U601.14 (DIF0#)
/REF_KC_DIF0P: U601.13 (DIF0)
/REF_KC_DIF1N: U601.17 (DIF1#)
/REF_KC_DIF1P: U601.16 (DIF1)
/REF_KC_DIF2N: U601.22 (DIF2#)
/REF_KC_DIF2P: U601.21 (DIF2)
/REF_KC_DIF3N: U601.26 (DIF3#)
/REF_KC_DIF3P: U601.25 (DIF3)
/REF_KC_DIF4N: U601.29 (DIF4#)
/REF_KC_DIF4P: U601.28 (DIF4)
/REF_KC_DIF5N: U601.33 (DIF5#)
/REF_KC_DIF5P: U601.32 (DIF5)
/REF_KC_DIF6N: U601.36 (DIF6#)
/REF_KC_DIF6P: U601.35 (DIF6)
/REF_KC_DIF7N: U601.40 (DIF7#)
/REF_KC_DIF7P: U601.39 (DIF7)
/REF_KC_REFCLKN: U601.5 (DIF_IN#)
/REF_KC_REFCLKP: U601.4 (DIF_IN)
/REF_KC_VDD: U601.10 (VDD), U601.15 (VDD), U601.19 (VDD), U601.27 (VDD), U601.34 (VDD), U601.38 (VDD), U601.42 (VDD)
/REF_KC_VDDA: U601.44 (VDDA)
/REF_KC_VDDR: U601.3 (VDDR)
/REF_SLIMA0_DET#: U601.11 (VOE0#)
/REF_SLIMA1_DET#: U601.41 (VOE7#)
/REF_SLIMA2_DET#: U601.23 (VOE2#)
/REF_SLIMA3_DET#: U601.18 (VOE1#)
/REF_SLIMB0_DET#: U601.24 (VOE3#)
/REF_SLIMB1_DET#: U601.30 (VOE4#)
/REF_SLIMB2_DET#: U601.31 (VOE5#)
/REF_SLIMB3_DET#: U601.37 (VOE6#)
/S04_PWR_DVDT: U14.7; also elsewhere on the board
/S04_PWR_ILM: U14.9; also elsewhere on the board
/S04_PWR_OV: U14.2; also elsewhere on the board
/S04_PWR_UV: U14.1; also elsewhere on the board
/S05_PWR_DVDT: U15.7; also elsewhere on the board
/S05_PWR_ILM: U15.9; also elsewhere on the board
/S05_PWR_OV: U15.2; also elsewhere on the board
/S05_PWR_UV: U15.1; also elsewhere on the board
/S06_PWR_DVDT: U16.7; also elsewhere on the board
/S06_PWR_ILM: U16.9; also elsewhere on the board
/S06_PWR_OV: U16.2; also elsewhere on the board
/S06_PWR_UV: U16.1; also elsewhere on the board
/S07_PWR_DVDT: U17.7; also elsewhere on the board
/S07_PWR_ILM: U17.9; also elsewhere on the board
/S07_PWR_OV: U17.2; also elsewhere on the board
/S07_PWR_UV: U17.1; also elsewhere on the board
/S08_PWR_DVDT: U18.7; also elsewhere on the board
/S08_PWR_ILM: U18.9; also elsewhere on the board
/S08_PWR_OV: U18.2; also elsewhere on the board
/S08_PWR_UV: U18.1; also elsewhere on the board
/S09_PWR_DVDT: U19.7; also elsewhere on the board
/S09_PWR_ILM: U19.9; also elsewhere on the board
/S09_PWR_OV: U19.2; also elsewhere on the board
/S09_PWR_UV: U19.1; also elsewhere on the board
/S10_PWR_DVDT: U20.7; also elsewhere on the board
/S10_PWR_ILM: U20.9; also elsewhere on the board
/S10_PWR_OV: U20.2; also elsewhere on the board
/S10_PWR_UV: U20.1; also elsewhere on the board
/VBANK_A: U14.5, U15.5, U30.5; also elsewhere on the board
/VBANK_B: U16.5, U17.5, U18.5, U19.5, U20.5; also elsewhere on the board
/VIN_A: U41.5; also elsewhere on the board
/VIN_B: U42.5; also elsewhere on the board

Schematic: Connectivity_20.kicad_sch, Main_10E1S / Connectivity 20

Parts:
U602: 9ZXL0851EKILFT / SUPPORT NETWORK PENDING; REF_9ZXL0851EKILFT_KU3
U603: 9FGV0241AKLF / SUPPORT NETWORK PENDING; REF_9FGV0241AKLF_KU2
U604: 9DML0451AKILF / SUPPORT NETWORK PENDING; REF_9DML0451AKILF_KU5
U605: TPS3808G09DBVR / SUPPORT NETWORK PENDING; REF_TPS3808G09DBVR_FU1
U606: W25Q32JWSSIQ_C2980995 / SUPPORT NETWORK PENDING; REF_W25Q32JWSSIQ_FU2
U607: TCA9548ARGER / SUPPORT NETWORK PENDING; REF_TCA9548ARGER_SU1

Connections:
/GND: U602.2 (GNDR), U602.49 (GND), U603.5 (GNDREF), U603.6 (GNDDIG), U603.10 (GND), U603.12 (vOE0#), U603.15 (GNDA), U603.21 (GND), U603.24 (GNDXTAL), U603.25 (EP), U604.7 (GNDR), U604.9 (^OE0#), U604.12 (^OE1#), U604.15 (GND), U604.19 (^OE2#), U604.22 (^OE3#), U604.24 (GNDR), U604.25 (TH), U605.2 (GND), U606.4 (GND), U607.9 (GND), U607.25 (EP); also elsewhere on the board
/P3V3_AUX: U605.6 (VDD), U607.21 (VCC); also elsewhere on the board
/PEX_0V9: U605.5 (SENSE); also elsewhere on the board
/PEX_1V8: U606.8 (VCC); also elsewhere on the board
/PEX_SPI_CLK: U606.6 (CLK); also elsewhere on the board
/PEX_SPI_CS_N: U606.1 (CS#); also elsewhere on the board
/PEX_SPI_IO0: U606.5 (IO0); also elsewhere on the board
/PEX_SPI_IO1: U606.2 (IO1); also elsewhere on the board
/PEX_SPI_IO2: U606.3 (IO2); also elsewhere on the board
/PEX_SPI_IO3: U606.7 (IO3); also elsewhere on the board
/PEX_SYS_RESET_N: U605.1 (RESET); also elsewhere on the board
/REF_KA_DIF0N: U603.14 (DIF0#)
/REF_KA_DIF0P: U603.13 (DIF0)
/REF_KA_OE1: U603.19 (vOE1#)
/REF_KA_PD#: U603.22 (^CKPWRGD_PD#)
/REF_KA_SSEN: U603.23 (vSS_EN_tri)
/REF_KA_VDD: U603.3 (VDDXTAL1.8), U603.7 (VDDDIG1.8), U603.11 (VDD1.8), U603.20 (VDD1.8)
/REF_KA_VDDA: U603.16 (VDDA1.8)
/REF_KA_X1: U603.1 (X1_25)
/REF_KA_X2: U603.2 (X2)
/REF_KB_DIF0N: U604.11 (DIF0#)
/REF_KB_DIF0P: U604.10 (DIF0)
/REF_KB_DIF1N: U604.14 (DIF1#)
/REF_KB_DIF1P: U604.13 (DIF1)
/REF_KB_DIF2N: U604.18 (DIF2#)
/REF_KB_DIF2P: U604.17 (DIF2)
/REF_KB_DIF3N: U604.21 (DIF3#)
/REF_KB_DIF3P: U604.20 (DIF3)
/REF_KB_MODE: U604.8 (vSW_MODE)
/REF_KB_SELAB: U604.23 (^SEL_A_B#)
/REF_KB_VDD: U604.16 (VDD3.3)
/REF_KB_VDDA: U604.3 (VDDR3.3A)
/REF_KB_VDDB: U604.4 (VDDR3.3B)
/REF_KD_100_133M: U602.47 (^100M_133M#)
/REF_KD_BYP#_HIBW_: U602.48 (^HIBW_BYPM_LOBW#)
/REF_KD_CK_PD#: U602.1 (^CKPWRGD_PD#)
/REF_KD_DIF0N: U602.14 (DIF0#)
/REF_KD_DIF0P: U602.13 (DIF0)
/REF_KD_DIF1N: U602.17 (DIF1#)
/REF_KD_DIF1P: U602.16 (DIF1)
/REF_KD_DIF2N: U602.22 (DIF2#)
/REF_KD_DIF2P: U602.21 (DIF2)
/REF_KD_DIF3N: U602.26 (DIF3#)
/REF_KD_DIF3P: U602.25 (DIF3)
/REF_KD_DIF4N: U602.29 (DIF4#)
/REF_KD_DIF4P: U602.28 (DIF4)
/REF_KD_DIF5N: U602.33 (DIF5#)
/REF_KD_DIF5P: U602.32 (DIF5)
/REF_KD_DIF6N: U602.36 (DIF6#)
/REF_KD_DIF6P: U602.35 (DIF6)
/REF_KD_DIF7N: U602.40 (DIF7#)
/REF_KD_DIF7P: U602.39 (DIF7)
/REF_KD_REFCLKN: U602.5 (DIF_IN#)
/REF_KD_REFCLKP: U602.4 (DIF_IN)
/REF_KD_VDD: U602.10 (VDD), U602.15 (VDD), U602.19 (VDD), U602.27 (VDD), U602.34 (VDD), U602.38 (VDD), U602.42 (VDD)
/REF_KD_VDDA: U602.44 (VDDA)
/REF_KD_VDDR: U602.3 (VDDR)
/REF_PERST_BUFF#: U607.24 (RESET#)
/REF_PE_REFCLKN: U604.2 (DIF_INA#)
/REF_PE_REFCLKP: U604.1 (DIF_INA)
/REF_PWRONRST_CT: U605.4 (CT)
/REF_PWRONRST_MR: U605.3 (MR)
/REF_SLIMA0_CLK: U607.17 (SC7)
/REF_SLIMA0_DAT: U607.16 (SD7)
/REF_SLIMA1_CLK: U607.15 (SC6)
/REF_SLIMA1_DAT: U607.14 (SD6)
/REF_SLIMA2_CLK: U607.13 (SC5)
/REF_SLIMA2_DAT: U607.12 (SD5)
/REF_SLIMA3_CLK: U607.11 (SC4)
/REF_SLIMA3_DAT: U607.10 (SD4)
/REF_SLIMB0_CLK: U607.8 (SC3)
/REF_SLIMB0_DAT: U607.7 (SD3)
/REF_SLIMB1_CLK: U607.6 (SC2)
/REF_SLIMB1_DAT: U607.5 (SD2)
/REF_SLIMB2_CLK: U607.4 (SC1)
/REF_SLIMB2_DAT: U607.3 (SD1)
/REF_SLIMB3_CLK: U607.2 (SC0)
/REF_SLIMB3_DAT: U607.1 (SD0)
/REF_SLIMC0_DET#: U602.31 (VOE5#)
/REF_SLIMC1_DET#: U602.37 (VOE6#)
/REF_SLIMC2_DET#: U602.24 (VOE3#)
/REF_SLIMC3_DET#: U602.30 (VOE4#)
/REF_SLIMD0_DET#: U602.11 (VOE0#)
/REF_SLIMD1_DET#: U602.41 (VOE7#)
/REF_SLIMD2_DET#: U602.23 (VOE2#)
/REF_SLIMD3_DET#: U602.18 (VOE1#)
/REF_SMB_A_A0: U607.22 (A0)
/REF_SMB_A_A1: U607.23 (A1)
/REF_SMB_A_A2: U607.18 (A2)
/REF_SMB_A_SCL: U607.19 (SCL)
/REF_SMB_A_SDA: U607.20 (SDA)
/REF_SRNS_REFCLKN: U604.6 (DIF_INB#)
/REF_SRNS_REFCLKP: U604.5 (DIF_INB)

Board: 32 copper layers, 211 parts (91 on the bottom side), 350 nets, no tracks yet.

Other parts of the board:
U501: Intel_JHL9580_MECH_13x13_UNVERIFIED
U502: Intel_Core_Ultra7_268V_MECH_27p5x27
